SUMMARY = "Contains the ROS middleware API."
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=12c26a18c7f493fdc7e8a93b16b7c04f"
DEPENDS = "rcutils ament-cmake-ros"

include rmw.inc

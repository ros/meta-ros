SUMMARY = "Python API to access the ament resource index."
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

include ament-index.inc

S = "${WORKDIR}/git/ament_index_python"

inherit setuptools3

SUMMARY = "A package containing some geometry related message definitions."
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=12c26a18c7f493fdc7e8a93b16b7c04f"
DEPENDS = "ros2-std-msgs"

ROS_BPN = "geometry_msgs"

include common-interfaces.inc

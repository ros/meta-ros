SUMMARY = "A package containing some message definitions used in the implementation or actions."
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=12c26a18c7f493fdc7e8a93b16b7c04f"
DEPENDS = " \
    builtin-interfaces \
    rosidl-default-runtime \
    rosidl-typesupport-cpp \
    ros2-std-msgs \
"

ROS_BPN = "actionlib_msgs"

include common-interfaces.inc

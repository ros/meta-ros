PACKAGECONFIG_append = " python"

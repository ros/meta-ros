LICENSE = "Apache-2.0 | EPL-2.0"

PACKAGECONFIG += "shared-memory unstable-api"

PACKAGECONFIG += "shared-memory unstable-api "

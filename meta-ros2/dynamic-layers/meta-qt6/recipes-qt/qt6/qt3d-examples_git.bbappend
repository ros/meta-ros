LICENSE = "CC-BY-4.0 AND LicenseRef-MIRAMAR AND (BSD-3-Clause OR LicenseRef-The-Qt-Company-Commercial)"
NO_GENERIC_LICENSE[MIRAMAR] = "LICENSES/LicenseRef-MIRAMAR.txt"

LICENSE = "Apache-2.0 AND MIT AND LicenseRef-Tango-Icons-Public-Domain AND (BSD-3-Clause OR LicenseRef-The-Qt-Company-Commercial)"
NO_GENERIC_LICENSE[Tango-Icons-Public-Domain] = "LICENSES/LicenseRef-Tango-Icons-Public-Domain.txt"

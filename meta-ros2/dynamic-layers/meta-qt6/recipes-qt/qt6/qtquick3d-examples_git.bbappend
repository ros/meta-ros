LICENSE = "CC0-1.0 AND MIT AND (BSD-3-Clause OR LicenseRef-The-Qt-Company-Commercial)"

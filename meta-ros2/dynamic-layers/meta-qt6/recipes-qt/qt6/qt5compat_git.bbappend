LICENSE = "BSD-2-Clause & (BSD-3-Clause & GFDL-1.3-no-invariants-only & GPL-3.0-only & LicenseRef-Qt-GPL-exception-1.0 & (GPL-2.0-only | GPL-3.0-only | LGPL-3.0-only) | LicenseRef-The-Qt-Company-Commercial)"

LICENSE = "Apache-2.0 AND OFL-1.1 AND (BSD-3-Clause OR LicenseRef-The-Qt-Company-Commercial)"

LICENSE = "GFDL-1.3-no-invariants-only AND GPL-3.0-only AND (GPL-2.0-only OR LGPL-3.0-only) OR LicenseRef-The-Qt-Company-Commercial"

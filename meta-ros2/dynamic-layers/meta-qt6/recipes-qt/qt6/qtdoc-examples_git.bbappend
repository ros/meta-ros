LICENSE = "Apache-2.0 AND CC-BY-4.0 AND CC-BY-SA-4.0 AND ISC AND (BSD-3-Clause OR LicenseRef-The-Qt-Company-Commercial)"

LICENSE = "BSD-3-Clause AND GFDL-1.3-no-invariants-only AND GPL-3.0-only OR LicenseRef-The-Qt-Company-Commercial"

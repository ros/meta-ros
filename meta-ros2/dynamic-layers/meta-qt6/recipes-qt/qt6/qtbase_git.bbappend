LICENSE = "\
  Apache-2.0 \
  AND BSD-3-Clause \
  AND BSL-1.0 \
  AND HPND \
  AND LGPL-2.1-or-later \
  AND MIT \
  AND (GFDL-1.3-no-invariants-only AND GPL-3.0-only AND LicenseRef-Qt-GPL-exception-1.0 AND (GPL-2.0-only OR GPL-3.0-only OR LGPL-3.0-only) \
  OR LicenseRef-The-Qt-Company-Commercial) \
"

LICENSE = "GPL-3.0-only OR LicenseRef-The-Qt-Company-Commercial"

LICENSE = "LicenseRef-The-Qt-Company-Commercial"

LICENSE = "LicenseRef-The-Qt-Company-Commercial OR GPL-3.0-only WITH Qt-GPL-exception-1.0"

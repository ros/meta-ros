LICENSE = "BSD-3-Clause AND CC-BY-SA-4.0 AND CC0-1.0 AND MIT AND MPL-2.0 AND (GFDL-1.3-no-invariants-only AND GPL-3.0-only AND (GPL-2.0-only OR GPL-3.0-only OR LGPL-3.0-only) OR LicenseRef-The-Qt-Company-Commercial)"

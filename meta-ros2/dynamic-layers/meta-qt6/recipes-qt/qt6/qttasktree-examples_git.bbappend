LICENSE = "BSD-3-Clause OR LicenseRef-The-Qt-Company-Commercial"

# Copyright (c) 2026 Wind River Systems, Inc.

# ERROR Missing dependencies:
#       setuptools>=75.8.1
inherit setuptools3

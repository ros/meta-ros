LICENSE = "GFDL-1.2-only AND LGPL-2.1-or-later"

# Enable QtSvg module for SVG icon rendering in ROS rqt
PYQT_MODULES:append = " QtSvg"
DEPENDS += "qtsvg"

python __anonymous() {
    bb.warn("ament-python.bbclass is deprecated, please use ros_ament_python.bbclass instead")
}

inherit ros_ament_python

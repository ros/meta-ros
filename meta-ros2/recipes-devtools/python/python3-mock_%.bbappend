# Used by launch-testing-native
BBCLASSEXTEND = "native"

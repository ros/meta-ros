require python-virtualenv.inc
inherit setuptools3

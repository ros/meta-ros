require python-mock.inc
inherit setuptools3

SRC_URI[md5sum] = "8f48ba3fd059e7cfad92f8354064adfd"
SRC_URI[sha256sum] = "2a572b715f09dd2f0a583d8aeb5bb67d7ed7a8fd31d193cf1227a99c16a67bc3"

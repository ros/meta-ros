# Copyright (c) 2025 Wind River Systems, Inc.

LDFLAGS += "-lm"

BBCLASSEXTEND = "native nativesdk"

require ../../generated-recipes/fuse/fuse-doc_${PV}.bb

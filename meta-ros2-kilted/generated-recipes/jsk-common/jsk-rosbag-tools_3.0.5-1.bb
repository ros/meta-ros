# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "The rosbag tools"
AUTHOR = "Iori Yanokura <yanokura@jsk.imi.i.u-tokyo.ac.jp>"
ROS_AUTHOR = "Iori Yanokura <yanokura@jsk.imi.i.u-tokyo.ac.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=6;endline=6;md5=4633480cdd27d7906aaf3ef4b72014b2"

ROS_CN = "jsk_common"
ROS_BPN = "jsk_rosbag_tools"

ROS_BUILD_DEPENDS = "\
    jpeg \
    jsk-ros1-ros2-compat \
    libwebp \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    ament-cmake-python-native \
    ros-environment-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    audio-common-msgs \
    cv-bridge \
    ffmpeg \
    jsk-ros1-ros2-compat \
    jsk-topic-tools \
    python3-numpy \
    python3-pyyaml \
    python3-scipy \
    python3-setuptools \
    python3-termcolor \
    python3-tqdm \
    sensor-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-pytest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/tork-a/jsk_common-release/archive/release/kilted/jsk_rosbag_tools/3.0.5-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/jsk_rosbag_tools"
SRC_URI = "git://github.com/tork-a/jsk_common-release;${ROS_BRANCH};protocol=https"
SRCREV = "1b4c8067ce173c591ae64ecb797d13af7fdf4200"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

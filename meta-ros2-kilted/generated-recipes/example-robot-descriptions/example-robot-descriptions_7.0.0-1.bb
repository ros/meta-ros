# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Set of robot URDFs for benchmarking and developed examples."
AUTHOR = "Guilhem Saurel <guilhem.saurel@laas.fr>"
ROS_AUTHOR = "Carlos Mastalli <carlos.mastalli@ed.ac.uk>"
HOMEPAGE = "https://github.com/gepetto/example-robot-descriptions"
SECTION = "devel"
LICENSE = "BSD-2-Clause AND Apache-2.0 AND BSD-2-Clause AND BSD-3-Clause AND BSD AND ISC AND MPL-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=2ac6d860cb803e383c653bdc1d2758c1"

ROS_CN = "example_robot_descriptions"
ROS_BPN = "example_robot_descriptions"

ROS_BUILD_DEPENDS = "\
    coal \
    git \
    jrl-cmakemodules \
    pinocchio \
    python3 \
    python3-numpy \
"

ROS_BUILDTOOL_DEPENDS = "\
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    coal \
    python3 \
    python3-numpy \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-cmake \
    coal \
    pinocchio \
    python3 \
    python3-numpy \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/example-robot-descriptions-release/archive/release/kilted/example_robot_descriptions/7.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/example_robot_descriptions"
SRC_URI = "git://github.com/ros2-gbp/example-robot-descriptions-release;${ROS_BRANCH};protocol=https"
SRCREV = "3412c5b7057c4e4545411e8127a9e8f5d3761d85"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "ROS2 LiDAR-inertial SLAM and multi-session alignment"
AUTHOR = "Meher Malladi <rm.meher97@gmail.com>"
HOMEPAGE = "https://prbonn.github.io/rko_slam/"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "rko_slam"
ROS_BPN = "rko_slam"

ROS_BUILD_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-nanoflann} \
    ${ROS_UNRESOLVED_DEP-robin-map-dev} \
    builtin-interfaces \
    geometry-msgs \
    libeigen \
    opencv \
    rclcpp \
    rclcpp-components \
    rko-lio \
    rosbag2-storage \
    sensor-msgs \
    sophus \
    spdlog \
    std-msgs \
    tf2 \
    tf2-ros \
    visualization-msgs \
    yaml-cpp \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-nanoflann} \
    ${ROS_UNRESOLVED_DEP-robin-map-dev} \
    builtin-interfaces \
    geometry-msgs \
    libeigen \
    opencv \
    rclcpp \
    rclcpp-components \
    rko-lio \
    rosbag2-storage \
    sensor-msgs \
    sophus \
    spdlog \
    std-msgs \
    tf2 \
    tf2-ros \
    visualization-msgs \
    yaml-cpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-nanoflann} \
    ${ROS_UNRESOLVED_DEP-robin-map-dev} \
    builtin-interfaces \
    geometry-msgs \
    libeigen \
    opencv \
    rclcpp \
    rclcpp-components \
    rko-lio \
    rosbag2-storage \
    sensor-msgs \
    sophus \
    spdlog \
    std-msgs \
    tf2 \
    tf2-ros \
    visualization-msgs \
    yaml-cpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    catch2 \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/rko_slam-release/archive/release/kilted/rko_slam/0.0.7-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/rko_slam"
SRC_URI = "git://github.com/ros2-gbp/rko_slam-release;${ROS_BRANCH};protocol=https"
SRCREV = "90c3003fa2ff213b9a73980240c5403c67fe614c"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

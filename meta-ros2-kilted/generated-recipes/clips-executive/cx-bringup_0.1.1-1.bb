# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Central CX bringup scripts and parameters for launching CLIPS example programs"
AUTHOR = "Tarik Viehmann <viehmann@kbsg.rwth-aachen.de>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "clips_executive"
ROS_BPN = "cx_bringup"

ROS_BUILD_DEPENDS = " \
    cx-ros-comm-gen \
    example-interfaces \
    launch-ros \
    pkgconfig \
    std-msgs \
    std-srvs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    cx-ros-comm-gen \
    example-interfaces \
    pkgconfig \
    std-msgs \
    std-srvs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    cx-ament-index-plugin \
    cx-clips-env-manager \
    cx-config-plugin \
    cx-example-plugin \
    cx-executive-plugin \
    cx-file-load-plugin \
    cx-protobuf-plugin \
    cx-ros-comm-gen \
    cx-ros-msgs-plugin \
    example-interfaces \
    launch-ros \
    pkgconfig \
    std-msgs \
    std-srvs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/clips_executive-release/archive/release/kilted/cx_bringup/0.1.1-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/cx_bringup"
SRC_URI = "git://github.com/ros2-gbp/clips_executive-release;${ROS_BRANCH};protocol=https"
SRCREV = "9af160e6e4fdf134c272c20044ce45880ff1a0e1"
ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

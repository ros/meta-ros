# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "A fast and flexible implementation of Rigid Body Dynamics algorithms and their analytical derivatives."
AUTHOR = "Justin Carpentier <justin.carpentier@inria.fr>"
HOMEPAGE = "https://github.com/stack-of-tasks/pinocchio"
SECTION = "devel"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=2ac6d860cb803e383c653bdc1d2758c1"

ROS_CN = "pinocchio"
ROS_BPN = "pinocchio"

ROS_BUILD_DEPENDS = " \
    boost \
    coal \
    doxygen \
    eigenpy \
    git \
    jrl-cmakemodules \
    libeigen \
    python3 \
    python3-numpy \
    ros-environment \
    urdfdom \
"

ROS_BUILDTOOL_DEPENDS = " \
    clang-native \
    cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    boost \
    coal \
    eigenpy \
    libeigen \
    python3 \
    python3-numpy \
    ros-environment \
    urdfdom \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    boost \
    coal \
    eigenpy \
    libeigen \
    python3 \
    python3-numpy \
    ros-environment \
    urdfdom \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/pinocchio-release/archive/release/kilted/pinocchio/4.0.0-2.tar.gz
ROS_BRANCH ?= "branch=release/kilted/pinocchio"
SRC_URI = "git://github.com/ros2-gbp/pinocchio-release;${ROS_BRANCH};protocol=https"
SRCREV = "9fc5a04624b06aa28a6fe21508b2c137b8ab27d2"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

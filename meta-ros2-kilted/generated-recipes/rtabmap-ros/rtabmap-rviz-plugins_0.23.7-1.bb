# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "RTAB-Map's rviz plugins."
AUTHOR = "Mathieu Labbe <matlabbe@gmail.com>"
ROS_AUTHOR = "Mathieu Labbe"
HOMEPAGE = "https://github.com/introlab/rtabmap_ros/issues"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "rtabmap_ros"
ROS_BPN = "rtabmap_rviz_plugins"

ROS_BUILD_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-qtbase5-private-dev} \
    pcl-conversions \
    pluginlib \
    rclcpp \
    ros-environment \
    rtabmap-conversions \
    rtabmap-msgs \
    rviz-common \
    rviz-default-plugins \
    rviz-rendering \
    sensor-msgs \
    std-msgs \
    tf2 \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-ros-native \
"

ROS_EXPORT_DEPENDS = "\
    pcl-conversions \
    pluginlib \
    rclcpp \
    rtabmap-conversions \
    rtabmap-msgs \
    rviz-common \
    rviz-default-plugins \
    rviz-rendering \
    sensor-msgs \
    std-msgs \
    tf2 \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-liboctomap-dev} \
    action-msgs \
    ament-index-cpp \
    ament-index-python \
    builtin-interfaces \
    class-loader \
    curl \
    cv-bridge \
    eigen3-cmake-module \
    fastcdr \
    freetype \
    gcc-runtime \
    geometry-msgs \
    glew \
    gtsam \
    gz-cmake-vendor \
    gz-math-vendor \
    gz-utils-vendor \
    image-geometry \
    image-transport \
    interactive-markers \
    laser-geometry \
    libcurl-vendor \
    libeigen \
    libg2o \
    libpointmatcher \
    libstatistics-collector \
    libtinyxml2 \
    libx11 \
    libxaw \
    libxrandr \
    libyaml \
    libyaml-vendor \
    lttng-ust \
    map-msgs \
    mesa \
    message-filters \
    nav-msgs \
    opencv \
    orocos-kdl \
    orocos-kdl-vendor \
    pcl \
    pcl-msgs \
    point-cloud-transport \
    python3-deprecated \
    python3-numpy \
    qt-gui-cpp \
    qtbase \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp-action \
    rclcpp-components \
    rcpputils \
    rcutils \
    resource-retriever \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-cmake \
    rosidl-core-runtime \
    rosidl-dynamic-typesupport \
    rosidl-generator-py \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    rtabmap \
    rviz-ogre-vendor \
    rviz-resource-interfaces \
    service-msgs \
    spdlog \
    spdlog-vendor \
    sqlite3 \
    statistics-msgs \
    std-srvs \
    tbb \
    tf2-eigen \
    tf2-geometry-msgs \
    tf2-msgs \
    tf2-ros \
    tinyxml2-vendor \
    tracetools \
    type-description-interfaces \
    unique-identifier-msgs \
    urdf \
    urdf-parser-plugin \
    urdfdom \
    urdfdom-headers \
    visualization-msgs \
    yaml-cpp \
    yaml-cpp-vendor \
    zlib \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-gmock-native \
    ament-cmake-gtest-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-native \
    ament-cmake-pytest-native \
    ament-cmake-python-native \
    ament-cmake-ros-core-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-package-native \
    cmake-native \
    eigen3-cmake-module-native \
    gcc-runtime-native \
    gmock-vendor-native \
    gtest-native \
    gtest-vendor-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-native \
    python3-pytest-native \
    python3-setuptools-native \
    rcpputils-native \
    rcutils-native \
    rosidl-cmake-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-type-description-native \
    rosidl-pycommon-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-interface-native \
"

ROS_EXEC_DEPENDS = "\
    pcl-conversions \
    pluginlib \
    rclcpp \
    rtabmap-conversions \
    rtabmap-msgs \
    rviz-common \
    rviz-default-plugins \
    rviz-rendering \
    sensor-msgs \
    std-msgs \
    tf2 \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/introlab/rtabmap_ros-release/archive/release/kilted/rtabmap_rviz_plugins/0.23.7-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/rtabmap_rviz_plugins"
SRC_URI = "git://github.com/introlab/rtabmap_ros-release;${ROS_BRANCH};protocol=https"
SRCREV = "6cfa0780f64bc551f26fba27e07f42f73f46bbb4"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

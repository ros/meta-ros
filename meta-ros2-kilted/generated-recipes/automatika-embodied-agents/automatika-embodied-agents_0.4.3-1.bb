# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "agents"
AUTHOR = "Automatika Robotics <contact@automatikarobotics.com>"
HOMEPAGE = "https://github.com/automatika-robotics/embodied-agents"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "automatika_embodied_agents"
ROS_BPN = "automatika_embodied_agents"

ROS_BUILD_DEPENDS = " \
    automatika-ros-sugar \
    builtin-interfaces \
    python3-httpx \
    python3-platformdirs \
    python3-tqdm \
    python3-websockets \
    sensor-msgs \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
    ament-cmake-python-native \
    rosidl-default-generators-native \
"

ROS_EXPORT_DEPENDS = " \
    automatika-ros-sugar \
    builtin-interfaces \
    python3-httpx \
    python3-platformdirs \
    python3-tqdm \
    python3-websockets \
    sensor-msgs \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    automatika-ros-sugar \
    builtin-interfaces \
    python3-httpx \
    python3-platformdirs \
    python3-tqdm \
    python3-websockets \
    rosidl-default-runtime \
    sensor-msgs \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    python3-pytest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/automatika_embodied_agents-release/archive/release/kilted/automatika_embodied_agents/0.4.3-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/automatika_embodied_agents"
SRC_URI = "git://github.com/ros2-gbp/automatika_embodied_agents-release;${ROS_BRANCH};protocol=https"
SRCREV = "ea832df03cdd9fdf4da06b671027a9f715d55ddf"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

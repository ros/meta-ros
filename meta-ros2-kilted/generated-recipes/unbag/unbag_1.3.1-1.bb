# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "A ROS 2 tool for exporting bags to human readable files. Supports pluggable export routines to handle any message type."
AUTHOR = "Lukas Ostendorf <lukas.ostendorf@ika.rwth-aachen.de>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "unbag"
ROS_BPN = "unbag"

ROS_BUILD_DEPENDS = "\
    python3 \
    python3-setuptools \
    qtbase \
    qtsvg \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    ament-cmake-python-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-index-python \
    opencv \
    python3-numpy \
    python3-pyyaml \
    python3-tqdm \
    qtsvg \
    rclpy \
    ros2cli \
    rosbag2-py \
    rosidl-runtime-py \
    sensor-msgs \
    tf2-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-pytest \
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/unbag-release/archive/release/kilted/unbag/1.3.1-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/unbag"
SRC_URI = "git://github.com/ros2-gbp/unbag-release;${ROS_BRANCH};protocol=https"
SRCREV = "c6ffb81dac076cd4dd5a7ce759fb604afea5bb30"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Controller for compensating for gravity on a group of joints"
AUTHOR = "Pyo <pyo@robotis.com>"
ROS_AUTHOR = "Woojin Wie <wwj@robotis.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=3dce4ba60d7e51ec64f3c3dc18672dd3"

ROS_CN = "open_manipulator"
ROS_BPN = "om_gravity_compensation_controller"

ROS_BUILD_DEPENDS = "\
    angles \
    backward-ros \
    control-msgs \
    control-toolbox \
    controller-interface \
    generate-parameter-library \
    hardware-interface \
    kdl-parser \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    realtime-tools \
    rsl \
    tl-expected \
    urdf \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    angles \
    backward-ros \
    control-msgs \
    control-toolbox \
    controller-interface \
    generate-parameter-library \
    hardware-interface \
    kdl-parser \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    realtime-tools \
    rsl \
    tl-expected \
    urdf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libexpected-dev} \
    action-msgs \
    ament-index-cpp \
    boost \
    builtin-interfaces \
    class-loader \
    diagnostic-msgs \
    eigen3-cmake-module \
    elfutils \
    fastcdr \
    filters \
    fmt \
    gcc-runtime \
    geometry-msgs \
    gz-cmake-vendor \
    gz-math-vendor \
    gz-tools-vendor \
    gz-utils-vendor \
    joint-limits \
    libcap \
    libeigen \
    libstatistics-collector \
    libtinyxml2 \
    libyaml \
    libyaml-vendor \
    lifecycle-msgs \
    lttng-ust \
    message-filters \
    orocos-kdl \
    orocos-kdl-vendor \
    pal-statistics \
    pal-statistics-msgs \
    parameter-traits \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-lifecycle \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp-action \
    rclcpp-components \
    rclpy \
    rcpputils \
    rcutils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-cmake \
    rosidl-core-runtime \
    rosidl-dynamic-typesupport \
    rosidl-generator-py \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    sdformat-urdf \
    sdformat-vendor \
    sensor-msgs \
    service-msgs \
    spdlog \
    spdlog-vendor \
    statistics-msgs \
    std-msgs \
    tcb-span \
    tf2 \
    tf2-geometry-msgs \
    tf2-msgs \
    tf2-ros \
    tinyxml2-vendor \
    tracetools \
    trajectory-msgs \
    type-description-interfaces \
    unique-identifier-msgs \
    urdf-parser-plugin \
    urdfdom \
    urdfdom-headers \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-gmock-native \
    ament-cmake-gtest-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-pytest-native \
    ament-cmake-python-native \
    ament-cmake-ros-core-native \
    ament-cmake-ros-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-package-native \
    cmake-native \
    gcc-runtime-native \
    generate-parameter-library-py-native \
    gmock-vendor-native \
    gtest-native \
    gtest-vendor-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-jinja2-native \
    python3-native \
    python3-pytest-native \
    python3-pyyaml-native \
    python3-setuptools-native \
    python3-typeguard-native \
    rcpputils-native \
    rcutils-native \
    rosidl-cmake-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-type-description-native \
    rosidl-pycommon-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-interface-native \
"

ROS_EXEC_DEPENDS = "\
    angles \
    backward-ros \
    control-msgs \
    control-toolbox \
    controller-interface \
    generate-parameter-library \
    hardware-interface \
    kdl-parser \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    realtime-tools \
    rsl \
    tl-expected \
    urdf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/open_manipulator-release/archive/release/kilted/om_gravity_compensation_controller/4.1.2-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/om_gravity_compensation_controller"
SRC_URI = "git://github.com/ros2-gbp/open_manipulator-release;${ROS_BRANCH};protocol=https"
SRCREV = "f8e2cc52ba9d7bc47929333f1aa3ee5b93927bb5"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "The depthai_examples package"
AUTHOR = "Aljaž Sebastjan Ahtik <sebastjan.ahtik@luxonis.com>"
ROS_AUTHOR = "Adam Serafin"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=92566b45c3390e5178465bcaade208b7"

ROS_CN = "depthai-ros"
ROS_BPN = "depthai_examples"

ROS_BUILD_DEPENDS = "\
    backward-ros \
    camera-info-manager \
    cv-bridge \
    depthai \
    depthai-bridge \
    depthai-descriptions \
    depthai-ros-msgs \
    foxglove-msgs \
    image-transport \
    nav-msgs \
    opencv \
    rclcpp \
    ros-environment \
    rviz-imu-plugin \
    sensor-msgs \
    std-msgs \
    stereo-msgs \
    vision-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    backward-ros \
    camera-info-manager \
    cv-bridge \
    depthai \
    depthai-bridge \
    depthai-descriptions \
    depthai-ros-msgs \
    foxglove-msgs \
    image-transport \
    nav-msgs \
    opencv \
    rclcpp \
    ros-environment \
    rviz-imu-plugin \
    sensor-msgs \
    std-msgs \
    stereo-msgs \
    vision-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-gfortran} \
    action-msgs \
    ament-index-cpp \
    ament-index-python \
    boost \
    builtin-interfaces \
    camera-calibration-parsers \
    class-loader \
    composition-interfaces \
    curl \
    eigen3-cmake-module \
    elfutils \
    fastcdr \
    ffmpeg-image-transport-msgs \
    fmt \
    freetype \
    gcc-runtime \
    geometry-msgs \
    glew \
    libcurl-vendor \
    libeigen \
    libstatistics-collector \
    libtinyxml2 \
    libusb1 \
    libx11 \
    libxaw \
    libxrandr \
    libyaml \
    libyaml-vendor \
    lttng-ust \
    mesa \
    message-filters \
    nlohmann-json \
    opencv \
    orocos-kdl \
    orocos-kdl-vendor \
    pluginlib \
    python3-numpy \
    qtbase \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp-action \
    rclcpp-components \
    rclcpp-lifecycle \
    rcpputils \
    rcutils \
    resource-retriever \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-cmake \
    rosidl-core-runtime \
    rosidl-default-generators \
    rosidl-dynamic-typesupport \
    rosidl-generator-py \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    rviz-common \
    rviz-ogre-vendor \
    rviz-rendering \
    service-msgs \
    spdlog \
    statistics-msgs \
    std-srvs \
    tf2 \
    tf2-geometry-msgs \
    tf2-msgs \
    tf2-ros \
    tinyxml2-vendor \
    tracetools \
    type-description-interfaces \
    udev \
    unique-identifier-msgs \
    unzip \
    urdf \
    urdf-parser-plugin \
    urdfdom \
    urdfdom-headers \
    yaml-cpp \
    yaml-cpp-vendor \
    zip \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    action-msgs-native \
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-ros-core-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-package-native \
    builtin-interfaces-native \
    cmake-native \
    eigen3-cmake-module-native \
    fastcdr-native \
    gcc-runtime-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-native \
    python3-setuptools-native \
    rcpputils-native \
    rcutils-native \
    rmw-native \
    ros-environment-native \
    rosidl-cmake-native \
    rosidl-core-generators-native \
    rosidl-core-runtime-native \
    rosidl-dynamic-typesupport-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-py-native \
    rosidl-generator-rs-native \
    rosidl-generator-type-description-native \
    rosidl-pycommon-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-cpp-native \
    rosidl-typesupport-fastrtps-c-native \
    rosidl-typesupport-fastrtps-cpp-native \
    rosidl-typesupport-interface-native \
    rosidl-typesupport-introspection-c-native \
    rosidl-typesupport-introspection-cpp-native \
    service-msgs-native \
    unique-identifier-msgs-native \
"

ROS_EXEC_DEPENDS = "\
    backward-ros \
    camera-info-manager \
    cv-bridge \
    depth-image-proc \
    depthai \
    depthai-bridge \
    depthai-descriptions \
    depthai-ros-msgs \
    foxglove-msgs \
    image-transport \
    nav-msgs \
    opencv \
    rclcpp \
    robot-state-publisher \
    ros-environment \
    rviz-imu-plugin \
    sensor-msgs \
    std-msgs \
    stereo-msgs \
    vision-msgs \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/luxonis/depthai-ros-release/archive/release/kilted/depthai_examples/3.3.0-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/depthai_examples"
SRC_URI = "git://github.com/luxonis/depthai-ros-release;${ROS_BRANCH};protocol=https"
SRCREV = "0637bbbb188c7eec0458c3bbfc4287c854e9b609"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

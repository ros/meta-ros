# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Provides an interface to read the sensor output of a SICK safeVisionary sensor in ROS 2"
AUTHOR = "Christian Eichmann <eichmann@fzi.de>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "sick_safevisionary_ros2"
ROS_BPN = "sick_safevisionary_driver"

ROS_BUILD_DEPENDS = " \
    boost \
    cv-bridge \
    lifecycle-msgs \
    rclcpp \
    rclcpp-lifecycle \
    sensor-msgs \
    sick-safevisionary-base \
    sick-safevisionary-interfaces \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    boost \
    cv-bridge \
    lifecycle-msgs \
    rclcpp \
    rclcpp-lifecycle \
    sensor-msgs \
    sick-safevisionary-base \
    sick-safevisionary-interfaces \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    cv-bridge \
    lifecycle-msgs \
    rclcpp \
    rclcpp-lifecycle \
    sensor-msgs \
    sick-safevisionary-base \
    sick-safevisionary-interfaces \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/sick_safevisionary_ros2-release/archive/release/kilted/sick_safevisionary_driver/1.0.4-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/sick_safevisionary_driver"
SRC_URI = "git://github.com/ros2-gbp/sick_safevisionary_ros2-release;${ROS_BRANCH};protocol=https"
SRCREV = "ca54f5f17aea909bb7f97b3d717d51c4bcac65b9"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Vendor package for the DART physics engine v6.13.2"
AUTHOR = "Addisu Taddese <addisu@intrinsic.ai>"
ROS_AUTHOR = "Addisu Taddese <addisu@intrinsic.ai>"
HOMEPAGE = "https://dartsim.github.io/"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0 & BSD-2"
LICENSE = "Apache-2.0 & BSD-2"
LIC_FILES_CHKSUM = "file://package.xml;beginline=21;endline=21;md5=f12ef8c0445c08084ae92cf2dcb7ee92"

ROS_CN = "gz_dartsim_vendor"
ROS_BPN = "gz_dartsim_vendor"

ROS_BUILD_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-liboctomap-dev} \
    assimp \
    boost \
    bullet \
    fcl \
    fmt \
    libccd \
    libeigen \
    libtinyxml2 \
    lz4 \
    ode \
    urdfdom \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    ament-cmake-vendor-package-native \
"

ROS_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-liboctomap-dev} \
    assimp \
    boost \
    bullet \
    fcl \
    fmt \
    libccd \
    libeigen \
    libtinyxml2 \
    lz4 \
    ode \
    urdfdom \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = ""

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-package-native \
    cmake-native \
    git-native \
    python3-catkin-pkg-native \
    python3-setuptools-native \
    python3-vcstool-native \
"

ROS_EXEC_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-liboctomap-dev} \
    assimp \
    boost \
    bullet \
    fcl \
    fmt \
    libccd \
    libeigen \
    libtinyxml2 \
    lz4 \
    ode \
    urdfdom \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-xmllint \
    ament-lint-auto \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/gz_dartsim_vendor-release/archive/release/kilted/gz_dartsim_vendor/0.1.2-2.tar.gz
ROS_BRANCH ?= "branch=release/kilted/gz_dartsim_vendor"
SRC_URI = "git://github.com/ros2-gbp/gz_dartsim_vendor-release;${ROS_BRANCH};protocol=https"
SRCREV = "5c999af495f0552b303da30cf153305ddebdba26"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

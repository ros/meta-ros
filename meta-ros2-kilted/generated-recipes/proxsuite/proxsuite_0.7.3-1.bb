# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "The Advanced Proximal Optimization Toolbox"
AUTHOR = "Justin Carpentier <justin.carpentier@inria.fr>"
ROS_AUTHOR = "Antoine Bambade <antoine.bambade@inria.fr>"
HOMEPAGE = "https://simple-robotics.github.io/proxsuite"
SECTION = "devel"
LICENSE = "BSD-2"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=6d936230566da2b5b6f908ac66e333a8"

ROS_CN = "proxsuite"
ROS_BPN = "proxsuite"

ROS_BUILD_DEPENDS = "\
    doxygen \
    git \
    libeigen \
    python3-numpy \
    python3-scipy \
"

ROS_BUILDTOOL_DEPENDS = "\
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    libeigen \
    python3-numpy \
    python3-scipy \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = ""

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    libeigen \
    python3-numpy \
    python3-scipy \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-matio} \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/proxsuite-release/archive/release/kilted/proxsuite/0.7.3-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/proxsuite"
SRC_URI = "git://github.com/ros2-gbp/proxsuite-release;${ROS_BRANCH};protocol=https"
SRCREV = "b21f5439896453c87c50e5e01f66af91a9fee3a4"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

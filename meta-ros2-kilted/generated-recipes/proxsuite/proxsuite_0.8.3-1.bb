# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "The Advanced Proximal Optimization Toolbox"
AUTHOR = "Justin Carpentier <justin.carpentier@inria.fr>"
ROS_AUTHOR = "Antoine Bambade <antoine.bambade@inria.fr>"
HOMEPAGE = "https://simple-robotics.github.io/proxsuite"
SECTION = "devel"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=2ac6d860cb803e383c653bdc1d2758c1"

ROS_CN = "proxsuite"
ROS_BPN = "proxsuite"

ROS_BUILD_DEPENDS = "\
    doxygen \
    git \
    graphviz \
    jrl-cmakemodules \
    libcereal \
    libeigen \
    python3 \
    python3-nanobind \
    python3-numpy \
    python3-scipy \
    ros-environment \
    simde \
"

ROS_BUILDTOOL_DEPENDS = "\
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    libcereal \
    libeigen \
    python3-nanobind \
    python3-numpy \
    python3-scipy \
    simde \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    libcereal \
    libeigen \
    python3-nanobind \
    python3-numpy \
    python3-scipy \
    simde \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-matio} \
    catch2 \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/proxsuite-release/archive/release/kilted/proxsuite/0.8.3-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/proxsuite"
SRC_URI = "git://github.com/ros2-gbp/proxsuite-release;${ROS_BRANCH};protocol=https"
SRCREV = "272a540de68f2a1e191add988058f1dd484c314a"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

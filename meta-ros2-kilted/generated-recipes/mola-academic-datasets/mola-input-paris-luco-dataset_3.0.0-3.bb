# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Offline RawDataSource from Paris LUCO (CT-ICP) odometry/SLAM datasets"
AUTHOR = "Jose-Luis Blanco-Claraco <joseluisblancoc@gmail.com>"
HOMEPAGE = "https://github.com/MOLAorg/mola/tree/develop/mola_input_paris_luco_dataset"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "GPLv3"
LICENSE = "GPL-3.0-only"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=e9f2deaa804a16d9e0d3965ef77e171e"

ROS_CN = "mola_academic_datasets"
ROS_BPN = "mola_input_paris_luco_dataset"

ROS_BUILD_DEPENDS = "\
    mola-common \
    mola-kernel \
    mrpt-libmaps \
"

ROS_BUILDTOOL_DEPENDS = "\
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    mola-common \
    mola-kernel \
    mrpt-libmaps \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    glfw \
    libeigen \
    mola-yaml \
    mrpt-libbase \
    mrpt-libgui \
    mrpt-libmath \
    mrpt-libobs \
    mrpt-libopengl \
    mrpt-libposes \
    nanoflann-vendor \
    suitesparse-cholmod \
    suitesparse-cxsparse \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    mola-common \
    mola-kernel \
    mrpt-libmaps \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/mola_academic_datasets-release/archive/release/kilted/mola_input_paris_luco_dataset/3.0.0-3.tar.gz
ROS_BRANCH ?= "branch=release/kilted/mola_input_paris_luco_dataset"
SRC_URI = "git://github.com/ros2-gbp/mola_academic_datasets-release;${ROS_BRANCH};protocol=https"
SRCREV = "afa62b4dcd1b9f21c9544ee371216d862085c6b3"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

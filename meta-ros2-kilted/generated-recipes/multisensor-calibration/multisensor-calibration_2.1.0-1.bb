# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Collection of methods and applications to calibrate multi-sensor-systems, e.g.     camera to LiDAR, LiDAR to LiDAR, and LiDAR to vehicle."
AUTHOR = "Miguel Granero <miguel.granero@iosb.fraunhofer.de>"
ROS_AUTHOR = "Boitumelo Ruf"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "multisensor_calibration"
ROS_BPN = "multisensor_calibration"

ROS_BUILD_DEPENDS = "\
    cv-bridge \
    geometry-msgs \
    image-transport \
    libtinyxml2 \
    multisensor-calibration-interface \
    pcl-conversions \
    pcl-ros \
    qtbase \
    rclcpp \
    rclcpp-components \
    rviz-common \
    sensor-msgs \
    small-gicp-vendor \
    std-msgs \
    tf2 \
    tf2-ros \
    urdf \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    cv-bridge \
    geometry-msgs \
    image-transport \
    libtinyxml2 \
    multisensor-calibration-interface \
    pcl-conversions \
    pcl-ros \
    rclcpp \
    rclcpp-components \
    rviz-common \
    sensor-msgs \
    small-gicp-vendor \
    std-msgs \
    tf2 \
    tf2-ros \
    urdf \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    action-msgs \
    ament-index-cpp \
    ament-index-python \
    builtin-interfaces \
    class-loader \
    curl \
    eigen3-cmake-module \
    fastcdr \
    freetype \
    gcc-runtime \
    glew \
    keyboard-handler \
    libcurl-vendor \
    libeigen \
    libstatistics-collector \
    libx11 \
    libxaw \
    libxrandr \
    libyaml \
    libyaml-vendor \
    lttng-ust \
    mesa \
    message-filters \
    opencv \
    orocos-kdl \
    orocos-kdl-vendor \
    pcl \
    pcl-msgs \
    pluginlib \
    python3-numpy \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp-action \
    rcpputils \
    rcutils \
    resource-retriever \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosbag2-compression \
    rosbag2-cpp \
    rosbag2-interfaces \
    rosbag2-storage \
    rosbag2-transport \
    rosgraph-msgs \
    rosidl-cmake \
    rosidl-core-runtime \
    rosidl-dynamic-typesupport \
    rosidl-generator-py \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    rviz-ogre-vendor \
    rviz-rendering \
    service-msgs \
    statistics-msgs \
    std-srvs \
    tf2-eigen \
    tf2-geometry-msgs \
    tf2-msgs \
    tinyxml2-vendor \
    tracetools \
    type-description-interfaces \
    unique-identifier-msgs \
    urdf-parser-plugin \
    urdfdom \
    urdfdom-headers \
    yaml-cpp \
    yaml-cpp-vendor \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-ros-core-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-package-native \
    cmake-native \
    eigen3-cmake-module-native \
    gcc-runtime-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-native \
    python3-setuptools-native \
    rcpputils-native \
    rcutils-native \
    rosidl-cmake-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-type-description-native \
    rosidl-pycommon-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-interface-native \
"

ROS_EXEC_DEPENDS = "\
    cv-bridge \
    geometry-msgs \
    image-transport \
    libtinyxml2 \
    multisensor-calibration-interface \
    pcl-conversions \
    pcl-ros \
    qtbase \
    rclcpp \
    rclcpp-components \
    rviz-common \
    sensor-msgs \
    small-gicp-vendor \
    std-msgs \
    tf2 \
    tf2-ros \
    urdf \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/multisensor_calibration-release/archive/release/kilted/multisensor_calibration/2.1.0-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/multisensor_calibration"
SRC_URI = "git://github.com/ros2-gbp/multisensor_calibration-release;${ROS_BRANCH};protocol=https"
SRCREV = "4b5d11879d30ac8a60e9cc373fef14750d3923b1"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

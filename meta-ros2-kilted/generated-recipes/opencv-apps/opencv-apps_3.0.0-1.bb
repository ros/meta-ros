# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "<p>opencv_apps provides various nodes that run internally OpenCV's functionalities and publish the result as ROS topics. With opencv_apps, you can skip writing OpenCV application codes for a lot of its functionalities by simply running a launch file that corresponds to OpenCV's functionality you want.</p>     <ul>       <li>You can have a look at all launch files provided here (be sure to choose the correct branch. As of Sept. 2016 indigo branch is used for ROS Indigo, Jade, and Kinetic distros).</li>       <li>The nodes are documented in <a href="https://ros-perception.github.io/opencv_apps/">the documentation</a> (and <a href="http://wiki.ros.org/opencv_apps">the wiki</a> for ROS 1).</li>     </ul>     <p>The most of code is originally taken from https://github.com/Itseez/opencv/tree/master/samples/cpp</p>"
AUTHOR = "Kei Okada <kei.okada@gmail.com>"
ROS_AUTHOR = "Kei Okada <kei.okada@gmail.com>"
HOMEPAGE = "https://ros-perception.github.io/opencv_apps/"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=17;endline=17;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "opencv_apps"
ROS_BPN = "opencv_apps"

ROS_BUILD_DEPENDS = "\
    class-loader \
    curl \
    cv-bridge \
    geometry-msgs \
    image-transport \
    message-filters \
    rclcpp \
    rclcpp-components \
    sensor-msgs \
    std-msgs \
    std-srvs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    ros-environment-native \
    rosidl-default-generators-native \
"

ROS_EXPORT_DEPENDS = "\
    sensor-msgs \
    std-msgs \
    std-srvs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    class-loader \
    curl \
    cv-bridge \
    geometry-msgs \
    image-transport \
    image-view \
    message-filters \
    rclcpp \
    rclcpp-components \
    rosidl-default-runtime \
    sensor-msgs \
    std-msgs \
    std-srvs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-index-python \
    compressed-image-transport \
    image-proc \
    image-publisher \
    launch-ros \
    launch-testing-ament-cmake \
    opencv \
    python3-numpy \
    rosidl-runtime-py \
    topic-tools \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros-perception/opencv_apps-release/archive/release/kilted/opencv_apps/3.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/opencv_apps"
SRC_URI = "git://github.com/ros-perception/opencv_apps-release;${ROS_BRANCH};protocol=https"
SRCREV = "5c6ff27a11b65f869a158ce2904496d49b6bc0a3"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

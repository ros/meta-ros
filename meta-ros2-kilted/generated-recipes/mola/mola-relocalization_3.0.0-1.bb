# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "C++ library with algorithms for relocalization, global localization, or pose estimation given a large initial uncertainty"
AUTHOR = "Jose-Luis Blanco-Claraco <joseluisblancoc@gmail.com>"
HOMEPAGE = "https://github.com/MOLAorg/mola/tree/develop/mola_relocalization"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "GPLv3"
LICENSE = "GPL-3.0-only"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=e9f2deaa804a16d9e0d3965ef77e171e"

ROS_CN = "mola"
ROS_BPN = "mola_relocalization"

ROS_BUILD_DEPENDS = "\
    mola-common \
    mola-pose-list \
    mp2p-icp \
    mrpt-libmaps \
    mrpt-libobs \
    mrpt-libslam \
"

ROS_BUILDTOOL_DEPENDS = "\
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    mola-common \
    mola-pose-list \
    mp2p-icp \
    mrpt-libmaps \
    mrpt-libobs \
    mrpt-libslam \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    cli11 \
    glfw \
    libeigen \
    mola-imu-preintegration \
    mp2p-icp-core \
    mp2p-icp-viz \
    mrpt-libbase \
    mrpt-libgui \
    mrpt-libmath \
    mrpt-libopengl \
    mrpt-libposes \
    nanoflann-vendor \
    suitesparse-cholmod \
    suitesparse-cxsparse \
    tbb \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    mola-common \
    mola-pose-list \
    mp2p-icp \
    mrpt-libmaps \
    mrpt-libobs \
    mrpt-libslam \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    mola-test-datasets \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/mola-release/archive/release/kilted/mola_relocalization/3.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/mola_relocalization"
SRC_URI = "git://github.com/ros2-gbp/mola-release;${ROS_BRANCH};protocol=https"
SRCREV = "396618c763a1e7efc929096a7d71f62bd033b954"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

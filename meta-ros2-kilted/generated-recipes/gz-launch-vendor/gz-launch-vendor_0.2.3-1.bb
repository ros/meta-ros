# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Vendor package for: gz-launch8 8.0.3      Gazebo Launch : Run and manage programs and plugins"
AUTHOR = "Addisu Z. Taddese <addisuzt@intrinsic.ai>"
HOMEPAGE = "https://github.com/gazebosim/gz-launch"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=20;endline=20;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "gz_launch_vendor"
ROS_BPN = "gz_launch_vendor"

ROS_BUILD_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libwebsockets-dev} \
    binutils \
    gflags \
    gz-cmake-vendor \
    gz-common-vendor \
    gz-gui-vendor \
    gz-math-vendor \
    gz-msgs-vendor \
    gz-plugin-vendor \
    gz-sim-vendor \
    gz-tools-vendor \
    gz-transport-vendor \
    libtinyxml2 \
    libxi \
    libxmu \
    libyaml \
    util-linux \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-test-native \
    ament-cmake-vendor-package-native \
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    gz-cmake-vendor \
    gz-common-vendor \
    gz-gui-vendor \
    gz-math-vendor \
    gz-msgs-vendor \
    gz-plugin-vendor \
    gz-sim-vendor \
    gz-tools-vendor \
    gz-transport-vendor \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-glslang-dev} \
    ${ROS_UNRESOLVED_DEP-glslc} \
    ${ROS_UNRESOLVED_DEP-libfreeimage-dev} \
    ${ROS_UNRESOLVED_DEP-liboctomap-dev} \
    ${ROS_UNRESOLVED_DEP-libx11-xcb-dev} \
    ${ROS_UNRESOLVED_DEP-libxcb-randr0-dev} \
    assimp \
    boost \
    bullet \
    fcl \
    fmt \
    freetype \
    gcc-runtime \
    gz-dartsim-vendor \
    gz-fuel-tools-vendor \
    gz-ogre-next-vendor \
    gz-physics-vendor \
    gz-rendering-vendor \
    gz-sensors-vendor \
    gz-utils-vendor \
    libccd \
    libeigen \
    libsdl2 \
    libx11 \
    libxaw \
    libxrandr \
    lz4 \
    mesa \
    ode \
    poco \
    rapidjson \
    sdformat-vendor \
    shaderc \
    spdlog \
    spdlog-vendor \
    tbb \
    urdfdom \
    vulkan-headers \
    zziplib \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-export-dependencies-native \
    ament-cmake-libraries-native \
    ament-package-native \
    git-native \
    python3-catkin-pkg-native \
    python3-setuptools-native \
    python3-vcstool-native \
"

ROS_EXEC_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libwebsockets-dev} \
    binutils \
    gflags \
    gz-cmake-vendor \
    gz-common-vendor \
    gz-gui-vendor \
    gz-math-vendor \
    gz-msgs-vendor \
    gz-plugin-vendor \
    gz-sim-vendor \
    gz-tools-vendor \
    gz-transport-vendor \
    libtinyxml2 \
    libxi \
    libxmu \
    libyaml \
    util-linux \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-xvfb} \
    ament-cmake-copyright \
    ament-cmake-lint-cmake \
    ament-cmake-xmllint \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/gz_launch_vendor-release/archive/release/kilted/gz_launch_vendor/0.2.3-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/gz_launch_vendor"
SRC_URI = "git://github.com/ros2-gbp/gz_launch_vendor-release;${ROS_BRANCH};protocol=https"
SRCREV = "26b01cbbf45c6729b423e12841e5bc041e61e0bb"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

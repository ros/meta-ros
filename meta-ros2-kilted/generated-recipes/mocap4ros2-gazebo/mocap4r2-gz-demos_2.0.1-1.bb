# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Gazebo demos of MOCAP4ROS2: robot ground truth and human motion in a simulated mocap room, streamed as MOCAP4ROS2 or as OptiTrack Motive"
AUTHOR = "Francisco Martín Rico <fmrico@gmail.com>"
ROS_AUTHOR = "Francisco Martín Rico <fmrico@gmail.com>"
HOMEPAGE = "https://mocap4ros2-project.github.io"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "mocap4ros2_gazebo"
ROS_BPN = "mocap4r2_gz_demos"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    launch \
    launch-ros \
    launch-yaml \
    mocap4r2-gz-plugin \
    mocap4r2-marker-viz \
    mocap4r2-motion-tools \
    mocap4r2-optitrack-driver \
    mocap4r2-robot-gt \
    ros-gz-bridge \
    ros-gz-sim \
    rviz2 \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/MOCAP4ROS2-Project/mocap4ros2_gazebo-release/archive/release/kilted/mocap4r2_gz_demos/2.0.1-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/mocap4r2_gz_demos"
SRC_URI = "git://github.com/MOCAP4ROS2-Project/mocap4ros2_gazebo-release;${ROS_BRANCH};protocol=https"
SRCREV = "0febf136dc9178f6b772c4a288b9b47b2777eff9"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Gazebo plugin simulating a motion capture room: markers on links, streamed as a MOCAP4ROS2 system or as an OptiTrack Motive server"
AUTHOR = "Francisco Martín Rico <fmrico@gmail.com>"
ROS_AUTHOR = "Francisco Martín Rico <fmrico@gmail.com>"
HOMEPAGE = "https://mocap4ros2-project.github.io"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "mocap4ros2_gazebo"
ROS_BPN = "mocap4r2_gz_plugin"

ROS_BUILD_DEPENDS = "\
    gz-plugin-vendor \
    gz-sim-vendor \
    lifecycle-msgs \
    mocap4r2-control \
    mocap4r2-interfaces \
    mocap4r2-optitrack-driver \
    rclcpp \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    gz-plugin-vendor \
    gz-sim-vendor \
    lifecycle-msgs \
    mocap4r2-control \
    mocap4r2-interfaces \
    mocap4r2-optitrack-driver \
    rclcpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    gz-plugin-vendor \
    gz-sim-vendor \
    launch \
    launch-ros \
    launch-yaml \
    lifecycle-msgs \
    mocap4r2-control \
    mocap4r2-interfaces \
    mocap4r2-optitrack-driver \
    rclcpp \
    ros-gz-bridge \
    ros-gz-sim \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/MOCAP4ROS2-Project/mocap4ros2_gazebo-release/archive/release/kilted/mocap4r2_gz_plugin/2.0.1-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/mocap4r2_gz_plugin"
SRC_URI = "git://github.com/MOCAP4ROS2-Project/mocap4ros2_gazebo-release;${ROS_BRANCH};protocol=https"
SRCREV = "e5588d107f1383a651d9f0b9366944c5b9db933a"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

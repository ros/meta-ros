# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "BTick - Lightweight client library for ROS 2 BehaviorTree observation and Nav2 logging"
AUTHOR = "Sherif Fathey <sheriffathey@outlook.com>"
ROS_AUTHOR = "Sherif Fathey <sheriffathey@outlook.com>"
HOMEPAGE = "https://github.com/SherifFathey/btick"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "btick"
ROS_BPN = "btick"

ROS_BUILD_DEPENDS = "\
    behaviortree-cpp \
    nlohmann-json \
    pugixml \
    rclcpp \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    behaviortree-cpp \
    nlohmann-json \
    pugixml \
    rclcpp \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    behaviortree-cpp \
    nlohmann-json \
    pugixml \
    rclcpp \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/SherifFathey/btick-release/archive/release/kilted/btick/1.0.1-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/btick"
SRC_URI = "git://github.com/SherifFathey/btick-release;${ROS_BRANCH};protocol=https"
SRCREV = "2b7c2798fe881cec665af917d293389190d2aca7"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

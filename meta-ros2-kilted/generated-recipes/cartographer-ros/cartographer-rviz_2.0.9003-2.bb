# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Cartographer is a system that provides real-time simultaneous localization     and mapping (SLAM) in 2D and 3D across multiple platforms and sensor     configurations. This package provides Cartographer's RViz integration."
AUTHOR = "Chris Lalancette <clalancette@openrobotics.org>"
ROS_AUTHOR = "The Cartographer Authors <google-cartographer@googlegroups.com>"
HOMEPAGE = "https://github.com/cartographer-project/cartographer_ros"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=b73cebba72f83c5afebf178817283e37"

ROS_CN = "cartographer_ros"
ROS_BPN = "cartographer_rviz"

ROS_BUILD_DEPENDS = "\
    abseil-cpp \
    boost \
    cartographer \
    cartographer-ros \
    cartographer-ros-msgs \
    libeigen \
    pluginlib \
    rclcpp \
    rviz-common \
    rviz-ogre-vendor \
    rviz-rendering \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    abseil-cpp \
    boost \
    cartographer \
    cartographer-ros \
    cartographer-ros-msgs \
    libeigen \
    pluginlib \
    rclcpp \
    rviz-common \
    rviz-ogre-vendor \
    rviz-rendering \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    action-msgs \
    ament-index-cpp \
    ament-index-python \
    builtin-interfaces \
    cairo \
    ceres-solver \
    class-loader \
    curl \
    fastcdr \
    freetype \
    gcc-runtime \
    geometry-msgs \
    gflags \
    glew \
    glog \
    libcurl-vendor \
    libstatistics-collector \
    libtinyxml2 \
    libx11 \
    libxaw \
    libxrandr \
    libyaml \
    libyaml-vendor \
    lttng-ust \
    lua \
    mesa \
    message-filters \
    nav-msgs \
    pcl \
    pcl-conversions \
    pcl-msgs \
    protobuf \
    qtbase \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp-action \
    rclcpp-components \
    rcpputils \
    rcutils \
    resource-retriever \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosbag2-cpp \
    rosbag2-storage \
    rosgraph-msgs \
    rosidl-cmake \
    rosidl-core-runtime \
    rosidl-dynamic-typesupport \
    rosidl-generator-py \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    sensor-msgs \
    service-msgs \
    statistics-msgs \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-eigen \
    tf2-msgs \
    tf2-ros \
    tinyxml2-vendor \
    tracetools \
    type-description-interfaces \
    unique-identifier-msgs \
    urdf \
    urdf-parser-plugin \
    urdfdom \
    urdfdom-headers \
    visualization-msgs \
    yaml-cpp \
    yaml-cpp-vendor \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-ros-core-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-package-native \
    cmake-native \
    eigen3-cmake-module-native \
    gcc-runtime-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-native \
    python3-setuptools-native \
    rcpputils-native \
    rcutils-native \
    rosidl-cmake-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-type-description-native \
    rosidl-pycommon-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-interface-native \
"

ROS_EXEC_DEPENDS = "\
    abseil-cpp \
    boost \
    cartographer \
    cartographer-ros \
    cartographer-ros-msgs \
    libeigen \
    pluginlib \
    rclcpp \
    rviz-common \
    rviz-ogre-vendor \
    rviz-rendering \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/cartographer_ros-release/archive/release/kilted/cartographer_rviz/2.0.9003-2.tar.gz
ROS_BRANCH ?= "branch=release/kilted/cartographer_rviz"
SRC_URI = "git://github.com/ros2-gbp/cartographer_ros-release;${ROS_BRANCH};protocol=https"
SRCREV = "39e313b0cddac9140d60c6ca3de61a0d823ebab8"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

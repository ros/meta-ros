# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Converts ROS messages to and from ASN.1-encoded ETSI ITS messages"
AUTHOR = "Jean-Pierre Busch <jean-pierre.busch@rwth-aachen.de>"
ROS_AUTHOR = "Jean-Pierre Busch <jean-pierre.busch@rwth-aachen.de>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=16;endline=16;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "etsi_its_messages"
ROS_BPN = "etsi_its_conversion"

ROS_BUILD_DEPENDS = "\
    etsi-its-cam-conversion \
    etsi-its-cam-ts-conversion \
    etsi-its-conversion-srvs \
    etsi-its-cpm-ts-conversion \
    etsi-its-denm-conversion \
    etsi-its-denm-ts-conversion \
    etsi-its-ivim-ts-conversion \
    etsi-its-mapem-ts-conversion \
    etsi-its-mcm-uulm-conversion \
    etsi-its-spatem-ts-conversion \
    etsi-its-vam-ts-conversion \
    rclcpp \
    rclcpp-components \
    ros-environment \
    udp-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    etsi-its-cam-conversion \
    etsi-its-cam-ts-conversion \
    etsi-its-conversion-srvs \
    etsi-its-cpm-ts-conversion \
    etsi-its-denm-conversion \
    etsi-its-denm-ts-conversion \
    etsi-its-ivim-ts-conversion \
    etsi-its-mapem-ts-conversion \
    etsi-its-mcm-uulm-conversion \
    etsi-its-spatem-ts-conversion \
    etsi-its-vam-ts-conversion \
    rclcpp \
    rclcpp-components \
    ros-environment \
    udp-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ament-index-cpp \
    builtin-interfaces \
    etsi-its-cam-coding \
    etsi-its-cam-msgs \
    etsi-its-cam-ts-coding \
    etsi-its-cam-ts-msgs \
    etsi-its-cpm-ts-coding \
    etsi-its-cpm-ts-msgs \
    etsi-its-denm-coding \
    etsi-its-denm-msgs \
    etsi-its-denm-ts-coding \
    etsi-its-denm-ts-msgs \
    etsi-its-ivim-ts-coding \
    etsi-its-ivim-ts-msgs \
    etsi-its-mapem-ts-coding \
    etsi-its-mapem-ts-msgs \
    etsi-its-mcm-uulm-coding \
    etsi-its-mcm-uulm-msgs \
    etsi-its-primitives-conversion \
    etsi-its-spatem-ts-coding \
    etsi-its-spatem-ts-msgs \
    etsi-its-vam-ts-coding \
    etsi-its-vam-ts-msgs \
    fastcdr \
    gcc-runtime \
    libstatistics-collector \
    libyaml \
    libyaml-vendor \
    lttng-ust \
    rcl \
    rcl-interfaces \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rcpputils \
    rcutils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-cmake \
    rosidl-core-runtime \
    rosidl-dynamic-typesupport \
    rosidl-generator-py \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    service-msgs \
    statistics-msgs \
    std-msgs \
    tracetools \
    type-description-interfaces \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-ros-core-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-package-native \
    cmake-native \
    gcc-runtime-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-native \
    python3-setuptools-native \
    rcpputils-native \
    rcutils-native \
    rosidl-cmake-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-type-description-native \
    rosidl-pycommon-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-interface-native \
"

ROS_EXEC_DEPENDS = "\
    etsi-its-cam-conversion \
    etsi-its-cam-ts-conversion \
    etsi-its-conversion-srvs \
    etsi-its-cpm-ts-conversion \
    etsi-its-denm-conversion \
    etsi-its-denm-ts-conversion \
    etsi-its-ivim-ts-conversion \
    etsi-its-mapem-ts-conversion \
    etsi-its-mcm-uulm-conversion \
    etsi-its-spatem-ts-conversion \
    etsi-its-vam-ts-conversion \
    rclcpp \
    rclcpp-components \
    ros-environment \
    udp-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/etsi_its_messages-release/archive/release/kilted/etsi_its_conversion/3.5.0-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/etsi_its_conversion"
SRC_URI = "git://github.com/ros2-gbp/etsi_its_messages-release;${ROS_BRANCH};protocol=https"
SRCREV = "280f82468b7a5cf1ec755a7f1c74c8a400fb6d8b"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

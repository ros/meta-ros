# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Inverse Kinematics solver for MoveIt"
AUTHOR = "Tyler Weaver <maybe@tylerjw.dev>"
ROS_AUTHOR = "Tyler Weaver <maybe@tylerjw.dev>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=4633480cdd27d7906aaf3ef4b72014b2"

ROS_CN = "pick_ik"
ROS_BPN = "pick_ik"

ROS_BUILD_DEPENDS = "\
    fmt \
    generate-parameter-library \
    moveit-core \
    pluginlib \
    range-v3 \
    rclcpp \
    rsl \
    tf2-geometry-msgs \
    tf2-kdl \
    tl-expected \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-ros-native \
"

ROS_EXPORT_DEPENDS = "\
    fmt \
    generate-parameter-library \
    moveit-core \
    pluginlib \
    range-v3 \
    rclcpp \
    rsl \
    tf2-geometry-msgs \
    tf2-kdl \
    tl-expected \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libexpected-dev} \
    ${ROS_UNRESOLVED_DEP-liboctomap-dev} \
    action-msgs \
    ament-index-cpp \
    ament-index-python \
    angles \
    assimp \
    backward-ros \
    boost \
    builtin-interfaces \
    bullet \
    class-loader \
    common-interfaces \
    console-bridge \
    console-bridge-vendor \
    curl \
    eigen-stl-containers \
    eigen3-cmake-module \
    elfutils \
    fastcdr \
    fcl \
    gcc-runtime \
    geometric-shapes \
    geometry-msgs \
    google-benchmark \
    google-benchmark-vendor \
    kdl-parser \
    libcurl-vendor \
    libeigen \
    libstatistics-collector \
    libtinyxml2 \
    libyaml \
    libyaml-vendor \
    lifecycle-msgs \
    lttng-ust \
    message-filters \
    moveit-common \
    moveit-msgs \
    object-recognition-msgs \
    octomap-msgs \
    orocos-kdl \
    orocos-kdl-vendor \
    osqp-vendor \
    parameter-traits \
    random-numbers \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-lifecycle \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp-action \
    rclcpp-components \
    rclcpp-lifecycle \
    rclpy \
    rcpputils \
    rcutils \
    resource-retriever \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-cmake \
    rosidl-core-runtime \
    rosidl-dynamic-typesupport \
    rosidl-generator-py \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    ruckig \
    sensor-msgs \
    service-msgs \
    shape-msgs \
    srdfdom \
    statistics-msgs \
    std-msgs \
    tcb-span \
    tf2 \
    tf2-eigen \
    tf2-msgs \
    tf2-ros \
    tinyxml2-vendor \
    tracetools \
    trajectory-msgs \
    type-description-interfaces \
    unique-identifier-msgs \
    urdf \
    urdf-parser-plugin \
    urdfdom \
    urdfdom-headers \
    visualization-msgs \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-gmock-native \
    ament-cmake-gtest-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-native \
    ament-cmake-pytest-native \
    ament-cmake-python-native \
    ament-cmake-ros-core-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-package-native \
    cmake-native \
    eigen3-cmake-module-native \
    gcc-runtime-native \
    generate-parameter-library-py-native \
    gmock-vendor-native \
    gtest-native \
    gtest-vendor-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-jinja2-native \
    python3-native \
    python3-pytest-native \
    python3-pyyaml-native \
    python3-setuptools-native \
    python3-typeguard-native \
    rcpputils-native \
    rcutils-native \
    rosidl-cmake-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-type-description-native \
    rosidl-pycommon-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-interface-native \
"

ROS_EXEC_DEPENDS = "\
    fmt \
    generate-parameter-library \
    moveit-core \
    pluginlib \
    range-v3 \
    rclcpp \
    rsl \
    tf2-geometry-msgs \
    tf2-kdl \
    tl-expected \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    moveit-resources-panda-moveit-config \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/pick_ik-release/archive/release/kilted/pick_ik/1.1.2-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/pick_ik"
SRC_URI = "git://github.com/ros2-gbp/pick_ik-release;${ROS_BRANCH};protocol=https"
SRCREV = "7feaa12156ddb013bd68ad28b3610403fab8a33a"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

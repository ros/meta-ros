# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Vendor package for the CLIPS rule based production system"
AUTHOR = "Tarik Viehmann <viehmann@kbsg.rwth-aachen.de>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT-0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=5fbf62ea9f085c36aa0f271ef59c9e89"

ROS_CN = "clips_vendor"
ROS_BPN = "clips_vendor"

ROS_BUILD_DEPENDS = " \
    ament-cmake-vendor-package \
    unzip \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    ament-cmake-vendor-package \
    unzip \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ament-cmake-vendor-package \
    unzip \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/clips_vendor-release/archive/release/kilted/clips_vendor/6.4.3-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/clips_vendor"
SRC_URI = "git://github.com/ros2-gbp/clips_vendor-release;${ROS_BRANCH};protocol=https"
SRCREV = "4f682cfbbc9eb4b48bebca4bc132b450f1b70733"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "roscontrol controller package conputing a linear feedback. The user needs     to provide a model of the robot and a list of controlled joint and the     controller computes a linear feedback on the user defined state."
AUTHOR = "Guilhem Saurel <guilhem.saurel@laas.fr>"
ROS_AUTHOR = "Maximilien Naveau"
HOMEPAGE = "https://github.com/loco-3d/linear-feedback-controller"
SECTION = "devel"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=2ac6d860cb803e383c653bdc1d2758c1"

ROS_CN = "linear_feedback_controller"
ROS_BPN = "linear_feedback_controller"

ROS_BUILD_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libexpected-dev} \
    control-toolbox \
    controller-interface \
    fmt \
    generate-parameter-library \
    hardware-interface \
    jrl-cmakemodules \
    libeigen \
    linear-feedback-controller-msgs \
    message-filters \
    nav-msgs \
    pal-statistics \
    pinocchio \
    pluginlib \
    rcl \
    rclcpp \
    rclcpp-lifecycle \
    realtime-tools \
    rosidl-dynamic-typesupport \
    sensor-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native \
    ament-cmake-python-native \
"

ROS_EXPORT_DEPENDS = "\
    control-toolbox \
    controller-interface \
    generate-parameter-library \
    hardware-interface \
    libeigen \
    linear-feedback-controller-msgs \
    message-filters \
    nav-msgs \
    pal-statistics \
    pinocchio \
    pluginlib \
    rcl \
    rclcpp \
    rclcpp-lifecycle \
    realtime-tools \
    rosidl-dynamic-typesupport \
    sensor-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-liboctomap-dev} \
    action-msgs \
    ament-index-cpp \
    assimp \
    backward-ros \
    boost \
    builtin-interfaces \
    class-loader \
    coal \
    control-msgs \
    diagnostic-msgs \
    doxygen \
    eigen3-cmake-module \
    eigenpy \
    elfutils \
    fastcdr \
    filters \
    gcc-runtime \
    geometry-msgs \
    gz-cmake-vendor \
    gz-math-vendor \
    gz-tools-vendor \
    gz-utils-vendor \
    joint-limits \
    libcap \
    libstatistics-collector \
    libtinyxml2 \
    libyaml \
    libyaml-vendor \
    lifecycle-msgs \
    lttng-ust \
    orocos-kdl \
    orocos-kdl-vendor \
    pal-statistics-msgs \
    parameter-traits \
    pkgconfig \
    python3 \
    python3-numpy \
    python3-scipy \
    rcl-action \
    rcl-interfaces \
    rcl-lifecycle \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp-action \
    rclcpp-components \
    rclpy \
    rcpputils \
    rcutils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    ros-environment \
    rosgraph-msgs \
    rosidl-cmake \
    rosidl-core-runtime \
    rosidl-generator-py \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    rsl \
    sdformat-urdf \
    sdformat-vendor \
    service-msgs \
    spdlog \
    spdlog-vendor \
    statistics-msgs \
    std-msgs \
    tcb-span \
    tf2 \
    tf2-eigen \
    tf2-geometry-msgs \
    tf2-msgs \
    tf2-ros \
    tinyxml2-vendor \
    tl-expected \
    tracetools \
    trajectory-msgs \
    type-description-interfaces \
    unique-identifier-msgs \
    urdf \
    urdf-parser-plugin \
    urdfdom \
    urdfdom-headers \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-gmock-native \
    ament-cmake-gtest-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-native \
    ament-cmake-pytest-native \
    ament-cmake-ros-core-native \
    ament-cmake-ros-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-package-native \
    cmake-native \
    gcc-runtime-native \
    generate-parameter-library-py-native \
    gmock-vendor-native \
    gtest-native \
    gtest-vendor-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-jinja2-native \
    python3-native \
    python3-pytest-native \
    python3-pyyaml-native \
    python3-setuptools-native \
    python3-typeguard-native \
    rcpputils-native \
    rcutils-native \
    rosidl-cmake-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-type-description-native \
    rosidl-pycommon-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-interface-native \
"

ROS_EXEC_DEPENDS = "\
    control-toolbox \
    controller-interface \
    generate-parameter-library \
    hardware-interface \
    linear-feedback-controller-msgs \
    message-filters \
    nav-msgs \
    pal-statistics \
    pinocchio \
    pluginlib \
    rcl \
    rclcpp \
    rclcpp-lifecycle \
    realtime-tools \
    rosidl-dynamic-typesupport \
    sensor-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    gmock-vendor \
    gtest-vendor \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/linear-feedback-controller-release/archive/release/kilted/linear_feedback_controller/4.0.1-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/linear_feedback_controller"
SRC_URI = "git://github.com/ros2-gbp/linear-feedback-controller-release;${ROS_BRANCH};protocol=https"
SRCREV = "0cf8b0eb4e15008cad36364a4d400b18d3d50efc"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

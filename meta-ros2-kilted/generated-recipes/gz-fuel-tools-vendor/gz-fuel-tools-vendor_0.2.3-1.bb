# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Vendor package for: gz-fuel_tools10 10.1.0      Gazebo Fuel Tools: Classes and tools for interacting with Gazebo Fuel"
AUTHOR = "Addisu Z. Taddese <addisuzt@intrinsic.ai>"
HOMEPAGE = "https://github.com/gazebosim/gz-fuel-tools"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=20;endline=20;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "gz_fuel_tools_vendor"
ROS_BPN = "gz_fuel_tools_vendor"

ROS_BUILD_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libcurl-dev} \
    gflags \
    gz-cmake-vendor \
    gz-common-vendor \
    gz-math-vendor \
    gz-msgs-vendor \
    gz-tools-vendor \
    gz-utils-vendor \
    jsoncpp \
    libtinyxml2 \
    libyaml \
    libzip \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-test-native \
    ament-cmake-vendor-package-native \
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    gz-cmake-vendor \
    gz-common-vendor \
    gz-math-vendor \
    gz-msgs-vendor \
    gz-tools-vendor \
    gz-utils-vendor \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    spdlog \
    spdlog-vendor \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-export-dependencies-native \
    ament-cmake-libraries-native \
    ament-package-native \
    git-native \
    python3-catkin-pkg-native \
    python3-setuptools-native \
    python3-vcstool-native \
"

ROS_EXEC_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libcurl-dev} \
    gflags \
    gz-cmake-vendor \
    gz-common-vendor \
    gz-math-vendor \
    gz-msgs-vendor \
    gz-tools-vendor \
    gz-utils-vendor \
    jsoncpp \
    libtinyxml2 \
    libyaml \
    libzip \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-copyright \
    ament-cmake-lint-cmake \
    ament-cmake-xmllint \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/gz_fuel_tools_vendor-release/archive/release/kilted/gz_fuel_tools_vendor/0.2.3-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/gz_fuel_tools_vendor"
SRC_URI = "git://github.com/ros2-gbp/gz_fuel_tools_vendor-release;${ROS_BRANCH};protocol=https"
SRCREV = "36a0774f63db27e20ec5c1627d20b951a750aeb7"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

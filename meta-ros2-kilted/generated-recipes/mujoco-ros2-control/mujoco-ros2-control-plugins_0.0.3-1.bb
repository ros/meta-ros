# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Plugin package for mujoco_ros2_control"
AUTHOR = "Nathan Dunkelberger <nathan.b.dunkelberger@nasa.gov>"
ROS_AUTHOR = "Sai Kishor Kothakota <sai.kishor@pal-robotics.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=17;endline=17;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "mujoco_ros2_control"
ROS_BPN = "mujoco_ros2_control_plugins"

ROS_BUILD_DEPENDS = " \
    backward-ros \
    geometry-msgs \
    mujoco-ros2-control-msgs \
    mujoco-vendor \
    pluginlib \
    rclcpp \
    realtime-tools \
    ros2-control-cmake \
    std-msgs \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    backward-ros \
    geometry-msgs \
    mujoco-ros2-control-msgs \
    mujoco-vendor \
    pluginlib \
    rclcpp \
    realtime-tools \
    ros2-control-cmake \
    std-msgs \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    backward-ros \
    geometry-msgs \
    mujoco-ros2-control-msgs \
    mujoco-vendor \
    pluginlib \
    rclcpp \
    realtime-tools \
    ros2-control-cmake \
    std-msgs \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-gtest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/mujoco_ros2_control-release/archive/release/kilted/mujoco_ros2_control_plugins/0.0.3-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/mujoco_ros2_control_plugins"
SRC_URI = "git://github.com/ros2-gbp/mujoco_ros2_control-release;${ROS_BRANCH};protocol=https"
SRCREV = "533539eaf49b4d39da3653852c01a2728af2249e"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

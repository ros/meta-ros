# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "C++ libraries for multi primitive-to-primitive (MP2P) ICP algorithms and point cloud processing pipelines, plus headless CLI applications. No GUI/display dependencies; see mp2p_icp_viz for the GUI apps."
AUTHOR = "Jose-Luis Blanco-Claraco <joseluisblancoc@gmail.com>"
HOMEPAGE = "https://github.com/MOLAorg/mp2p_icp"
SECTION = "devel"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=280b383e0b4a9ed1c76c2784614af882"

ROS_CN = "mp2p_icp"
ROS_BPN = "mp2p_icp_core"

ROS_BUILD_DEPENDS = "\
    cli11 \
    mola-common \
    mola-imu-preintegration \
    mrpt-libbase \
    mrpt-libmaps \
    mrpt-libobs \
    mrpt-libposes \
    ros-environment \
    tbb \
"

ROS_BUILDTOOL_DEPENDS = "\
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    cli11 \
    mola-common \
    mola-imu-preintegration \
    mrpt-libbase \
    mrpt-libmaps \
    mrpt-libobs \
    mrpt-libposes \
    tbb \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    libeigen \
    mrpt-libmath \
    mrpt-libopengl \
    nanoflann-vendor \
    suitesparse-cholmod \
    suitesparse-cxsparse \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    cli11 \
    mola-common \
    mola-imu-preintegration \
    mrpt-libbase \
    mrpt-libmaps \
    mrpt-libobs \
    mrpt-libposes \
    tbb \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/mp2p_icp-release/archive/release/kilted/mp2p_icp_core/2.12.0-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/mp2p_icp_core"
SRC_URI = "git://github.com/ros2-gbp/mp2p_icp-release;${ROS_BRANCH};protocol=https"
SRCREV = "c3ee763030092b07ffdb13a575cd8f21a9116bdf"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Easy Navigation: GPS Localizer package."
AUTHOR = "Jose Miguel Guerrero Hernandez <josemiguel.guerrero@urjc.es>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "easynav_plugins"
ROS_BPN = "easynav_gps_localizer"

ROS_BUILD_DEPENDS = "\
    easynav-common \
    easynav-core \
    geographic-msgs \
    geographiclib \
    geometry-msgs \
    nav-msgs \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    sensor-msgs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    easynav-common \
    easynav-core \
    geographic-msgs \
    geographiclib \
    geometry-msgs \
    nav-msgs \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    sensor-msgs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    action-msgs \
    ament-index-cpp \
    builtin-interfaces \
    class-loader \
    cv-bridge \
    easynav-sensors \
    eigen3-cmake-module \
    fastcdr \
    gcc-runtime \
    keyboard-handler \
    libeigen \
    libstatistics-collector \
    libtinyxml2 \
    libyaml \
    libyaml-vendor \
    lttng-ust \
    message-filters \
    opencv \
    orocos-kdl \
    orocos-kdl-vendor \
    pcl \
    pcl-conversions \
    pcl-msgs \
    pcl-ros \
    python3-numpy \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp-action \
    rclcpp-components \
    rcpputils \
    rcutils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosbag2-compression \
    rosbag2-cpp \
    rosbag2-interfaces \
    rosbag2-storage \
    rosbag2-transport \
    rosgraph-msgs \
    rosidl-cmake \
    rosidl-core-runtime \
    rosidl-dynamic-typesupport \
    rosidl-generator-py \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    service-msgs \
    statistics-msgs \
    std-msgs \
    tf2-eigen \
    tf2-msgs \
    tinyxml2-vendor \
    tracetools \
    type-description-interfaces \
    unique-identifier-msgs \
    vision-msgs \
    visualization-msgs \
    yaets \
    yaml-cpp \
    yaml-cpp-vendor \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-ros-core-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-package-native \
    cmake-native \
    gcc-runtime-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-native \
    python3-setuptools-native \
    rcpputils-native \
    rcutils-native \
    rosidl-cmake-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-type-description-native \
    rosidl-pycommon-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-interface-native \
"

ROS_EXEC_DEPENDS = "\
    easynav-common \
    easynav-core \
    geographic-msgs \
    geographiclib \
    geometry-msgs \
    nav-msgs \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    sensor-msgs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/EasyNavigation/easynav_plugins-release/archive/release/kilted/easynav_gps_localizer/0.4.1-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/easynav_gps_localizer"
SRC_URI = "git://github.com/EasyNavigation/easynav_plugins-release;${ROS_BRANCH};protocol=https"
SRCREV = "6219f40895dc0689140e62fd6372cd4901413d67"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Generate the ROS interfaces in Rust."
AUTHOR = "Esteve Fernandez <esteve@apache.org>"
ROS_AUTHOR = "Esteve Fernandez <esteve@apache.org>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "rosidl_rust"
ROS_BPN = "rosidl_generator_rs"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    ros-environment-native \
"

ROS_EXPORT_DEPENDS = "\
    rosidl-generator-c \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-native \
    ros-environment-native \
    rosidl-pycommon-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-interface-native \
"

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    gcc-runtime \
    rcutils \
    rosidl-cmake \
    rosidl-generator-type-description \
    rosidl-typesupport-interface \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-package-native \
    cmake-native \
    gcc-runtime-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-native \
    python3-setuptools-native \
    rcpputils-native \
    rcutils-native \
    rosidl-runtime-c-native \
"

ROS_EXEC_DEPENDS = "\
    rosidl-generator-c \
    rosidl-parser \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-lint-auto \
    ament-lint-common \
    rosidl-generator-c \
    rosidl-pycommon \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/rosidl_rust-release/archive/release/kilted/rosidl_generator_rs/0.5.0-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/rosidl_generator_rs"
SRC_URI = "git://github.com/ros2-gbp/rosidl_rust-release;${ROS_BRANCH};protocol=https"
SRCREV = "e6393cad20bd5200c9a7d42baade174caef44566"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

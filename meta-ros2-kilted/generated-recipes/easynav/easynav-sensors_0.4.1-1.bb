# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Easy Navigation: Sensors package."
AUTHOR = "Francisco Martín Rico <fmrico@gmail.com>"
ROS_AUTHOR = "Francisco Martín Rico"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "easynav"
ROS_BPN = "easynav_sensors"

ROS_BUILD_DEPENDS = "\
    cv-bridge \
    easynav-common \
    geometry-msgs \
    nav-msgs \
    pcl-conversions \
    pcl-ros \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    sensor-msgs \
    tf2-geometry-msgs \
    tf2-ros \
    vision-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    cv-bridge \
    easynav-common \
    geometry-msgs \
    nav-msgs \
    pcl-conversions \
    pcl-ros \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    sensor-msgs \
    tf2-geometry-msgs \
    tf2-ros \
    vision-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    cv-bridge \
    easynav-common \
    geometry-msgs \
    nav-msgs \
    pcl-conversions \
    pcl-ros \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    sensor-msgs \
    tf2-geometry-msgs \
    tf2-ros \
    vision-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/EasyNavigation/EasyNavigation-release/archive/release/kilted/easynav_sensors/0.4.1-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/easynav_sensors"
SRC_URI = "git://github.com/EasyNavigation/EasyNavigation-release;${ROS_BRANCH};protocol=https"
SRCREV = "701552b2846cb878887f198b4b918969df6d94ba"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

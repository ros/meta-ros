# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Standard AutoAPMS behavior tree nodes and deployment tools"
AUTHOR = "Robin Müller <mue.robin@icloud.com>"
HOMEPAGE = "https://autoapms.github.io/auto-apms-guide/"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "autoapms"
ROS_BPN = "auto_apms_behavior_tree"

ROS_BUILD_DEPENDS = "\
    ament-index-python \
    auto-apms-behavior-tree-core \
    auto-apms-interfaces \
    auto-apms-util \
    generate-parameter-library \
    geometry-msgs \
    rcl-interfaces \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    std-srvs \
    tf2-geometry-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    ament-cmake-python-native \
"

ROS_EXPORT_DEPENDS = "\
    ament-index-python \
    auto-apms-behavior-tree-core \
    auto-apms-interfaces \
    auto-apms-util \
    generate-parameter-library \
    geometry-msgs \
    rcl-interfaces \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    std-srvs \
    tf2-geometry-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libexpected-dev} \
    action-msgs \
    ament-index-cpp \
    behaviortree-cpp \
    builtin-interfaces \
    class-loader \
    eigen3-cmake-module \
    fastcdr \
    fmt \
    gcc-runtime \
    libeigen \
    libstatistics-collector \
    libtinyxml2 \
    libyaml \
    libyaml-vendor \
    lifecycle-msgs \
    lttng-ust \
    message-filters \
    orocos-kdl \
    orocos-kdl-vendor \
    parameter-traits \
    pluginlib \
    rcl \
    rcl-action \
    rcl-lifecycle \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp-lifecycle \
    rclpy \
    rcpputils \
    rcutils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-cmake \
    rosidl-core-runtime \
    rosidl-dynamic-typesupport \
    rosidl-generator-py \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    rsl \
    service-msgs \
    sqlite3 \
    statistics-msgs \
    std-msgs \
    tcb-span \
    tf2 \
    tf2-msgs \
    tf2-ros \
    tinyxml2-vendor \
    tl-expected \
    tracetools \
    type-description-interfaces \
    unique-identifier-msgs \
    yaml-cpp \
    yaml-cpp-vendor \
    zeromq \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-ros-core-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-package-native \
    cmake-native \
    gcc-runtime-native \
    generate-parameter-library-py-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-jinja2-native \
    python3-native \
    python3-pyyaml-native \
    python3-setuptools-native \
    python3-typeguard-native \
    rcpputils-native \
    rcutils-native \
    rosidl-cmake-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-type-description-native \
    rosidl-pycommon-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-interface-native \
"

ROS_EXEC_DEPENDS = "\
    ament-index-python \
    auto-apms-behavior-tree-core \
    auto-apms-interfaces \
    auto-apms-util \
    generate-parameter-library \
    geometry-msgs \
    rcl-interfaces \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rclpy \
    ros2cli \
    ros2param \
    std-srvs \
    tf2-geometry-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-copyright \
    ament-cmake-gtest \
    ament-cmake-pytest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/autoapms-release/archive/release/kilted/auto_apms_behavior_tree/1.5.1-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/auto_apms_behavior_tree"
SRC_URI = "git://github.com/ros2-gbp/autoapms-release;${ROS_BRANCH};protocol=https"
SRCREV = "a726758b8cd4cfec8961e8eca5dd714c515d4ea7"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Simple wrapper around SocketCAN"
AUTHOR = "Ramon Wijnands <ramon.wijnands@nobleo.nl>"
ROS_AUTHOR = "Ramon Wijnands <ramon.wijnands@nobleo.nl>"
HOMEPAGE = "https://github.com/nobleo/nobleo_socketcan_bridge"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=15;endline=15;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "nobleo_socketcan_bridge"
ROS_BPN = "nobleo_socketcan_bridge"

ROS_BUILD_DEPENDS = " \
    ament-cmake-ros \
    can-msgs \
    diagnostic-msgs \
    diagnostic-updater \
    fmt \
    rclcpp \
    rclcpp-components \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    can-msgs \
    diagnostic-msgs \
    diagnostic-updater \
    fmt \
    rclcpp \
    rclcpp-components \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    can-msgs \
    diagnostic-msgs \
    diagnostic-updater \
    fmt \
    rclcpp \
    rclcpp-components \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-clang-format \
    ament-cmake-cppcheck \
    ament-cmake-cpplint \
    ament-cmake-lint-cmake \
    ament-cmake-xmllint \
    ament-lint-auto \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/nobleo_socketcan_bridge-release/archive/release/kilted/nobleo_socketcan_bridge/1.0.2-2.tar.gz
ROS_BRANCH ?= "branch=release/kilted/nobleo_socketcan_bridge"
SRC_URI = "git://github.com/ros2-gbp/nobleo_socketcan_bridge-release;${ROS_BRANCH};protocol=https"
SRCREV = "412fda7b38df885b80d2c19cb358287b05e1d381"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

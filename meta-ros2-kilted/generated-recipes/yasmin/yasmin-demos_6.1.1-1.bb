# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Demos of YASMIN (Yet Another State MachINe)"
AUTHOR = "Miguel Ángel González Santamarta <mgons@unileon.es>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "yasmin"
ROS_BPN = "yasmin_demos"

ROS_BUILD_DEPENDS = "\
    ament-index-cpp \
    example-interfaces \
    geometry-msgs \
    nav-msgs \
    pluginlib \
    rclcpp \
    rclcpp-action \
    rclpy \
    ros-environment \
    yasmin \
    yasmin-factory \
    yasmin-ros \
    yasmin-viewer \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    ament-cmake-python-native \
"

ROS_EXPORT_DEPENDS = "\
    ament-index-cpp \
    example-interfaces \
    geometry-msgs \
    nav-msgs \
    pluginlib \
    rclcpp \
    rclcpp-action \
    rclpy \
    yasmin \
    yasmin-factory \
    yasmin-ros \
    yasmin-viewer \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-index-cpp \
    example-interfaces \
    geometry-msgs \
    nav-msgs \
    pluginlib \
    rclcpp \
    rclcpp-action \
    rclpy \
    yasmin \
    yasmin-factory \
    yasmin-ros \
    yasmin-viewer \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/yasmin-release/archive/release/kilted/yasmin_demos/6.1.1-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/yasmin_demos"
SRC_URI = "git://github.com/ros2-gbp/yasmin-release;${ROS_BRANCH};protocol=https"
SRCREV = "aca2eddcdaa7d83b6aaaad200467d75c171f3dee"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

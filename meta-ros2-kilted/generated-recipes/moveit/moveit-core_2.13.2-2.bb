# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "Core libraries used by MoveIt"
AUTHOR = "Henning Kayser <henningkayser@picknik.ai>"
ROS_AUTHOR = "Ioan Sucan <isucan@google.com>"
HOMEPAGE = "http://moveit.ros.org"
SECTION = "devel"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=4633480cdd27d7906aaf3ef4b72014b2"

ROS_CN = "moveit"
ROS_BPN = "moveit_core"

ROS_BUILD_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-liboctomap-dev} \
    angles \
    assimp \
    boost \
    bullet \
    common-interfaces \
    eigen-stl-containers \
    fcl \
    generate-parameter-library \
    geometric-shapes \
    geometry-msgs \
    google-benchmark-vendor \
    kdl-parser \
    libeigen \
    moveit-common \
    moveit-msgs \
    octomap-msgs \
    osqp-vendor \
    pluginlib \
    random-numbers \
    rclcpp \
    rsl \
    ruckig \
    sensor-msgs \
    shape-msgs \
    srdfdom \
    std-msgs \
    tf2 \
    tf2-eigen \
    tf2-geometry-msgs \
    tf2-kdl \
    trajectory-msgs \
    urdf \
    urdfdom \
    urdfdom-headers \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
    eigen3-cmake-module-native \
    pkgconfig-native \
"

ROS_EXPORT_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-liboctomap-dev} \
    angles \
    assimp \
    boost \
    bullet \
    common-interfaces \
    eigen-stl-containers \
    fcl \
    generate-parameter-library \
    geometric-shapes \
    geometry-msgs \
    google-benchmark-vendor \
    kdl-parser \
    libeigen \
    moveit-common \
    moveit-msgs \
    octomap-msgs \
    osqp-vendor \
    pluginlib \
    random-numbers \
    rclcpp \
    rsl \
    ruckig \
    sensor-msgs \
    shape-msgs \
    srdfdom \
    std-msgs \
    tf2 \
    tf2-eigen \
    tf2-geometry-msgs \
    tf2-kdl \
    trajectory-msgs \
    urdf \
    urdfdom \
    urdfdom-headers \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = " \
    eigen3-cmake-module-native \
"

ROS_EXEC_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-liboctomap-dev} \
    angles \
    assimp \
    boost \
    bullet \
    common-interfaces \
    eigen-stl-containers \
    fcl \
    generate-parameter-library \
    geometric-shapes \
    geometry-msgs \
    google-benchmark-vendor \
    kdl-parser \
    libeigen \
    moveit-common \
    moveit-msgs \
    octomap-msgs \
    osqp-vendor \
    pluginlib \
    random-numbers \
    rclcpp \
    rsl \
    ruckig \
    sensor-msgs \
    shape-msgs \
    srdfdom \
    std-msgs \
    tf2 \
    tf2-eigen \
    tf2-geometry-msgs \
    tf2-kdl \
    trajectory-msgs \
    urdf \
    urdfdom \
    urdfdom-headers \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-gmock \
    ament-cmake-google-benchmark \
    ament-cmake-gtest \
    ament-index-cpp \
    angles \
    launch-testing-ament-cmake \
    moveit-resources-panda-moveit-config \
    moveit-resources-pr2-description \
    orocos-kdl-vendor \
    rcl-interfaces \
    rclpy \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/moveit2-release/archive/release/kilted/moveit_core/2.13.2-2.tar.gz
ROS_BRANCH ?= "branch=release/kilted/moveit_core"
SRC_URI = "git://github.com/ros2-gbp/moveit2-release;${ROS_BRANCH};protocol=https"
SRCREV = "d27da4a6280f0b608affa7efb2f25bb4f54379aa"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

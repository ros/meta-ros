# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_kilted
inherit ros_superflore_generated

DESCRIPTION = "A template-based Library for creating curves of arbitrary order and dimension"
AUTHOR = "Guilhem Saurel <guilhem.saurel@laas.fr>"
ROS_AUTHOR = "Pierre Fernbach"
HOMEPAGE = "http://github.com/loco-3d/ndcurves"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "ndcurves"
ROS_BPN = "ndcurves"

ROS_BUILD_DEPENDS = "\
    boost \
    doxygen \
    eigenpy \
    git \
    graphviz \
    jrl-cmakemodules \
    libeigen \
    pinocchio \
"

ROS_BUILDTOOL_DEPENDS = "\
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    boost \
    eigenpy \
    graphviz \
    jrl-cmakemodules \
    libeigen \
    pinocchio \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-liboctomap-dev} \
    assimp \
    coal \
    pkgconfig \
    python3 \
    python3-numpy \
    python3-scipy \
    ros-environment \
    urdfdom \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-cmake \
    boost \
    eigenpy \
    graphviz \
    jrl-cmakemodules \
    libeigen \
    pinocchio \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/ndcurves-release/archive/release/kilted/ndcurves/2.3.0-1.tar.gz
ROS_BRANCH ?= "branch=release/kilted/ndcurves"
SRC_URI = "git://github.com/ros2-gbp/ndcurves-release;${ROS_BRANCH};protocol=https"
SRCREV = "91e739d5d6447b9b753f64484436d2ab04439c20"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

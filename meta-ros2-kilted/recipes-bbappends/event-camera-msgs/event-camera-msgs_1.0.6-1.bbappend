# Copyright (c) 2024 Wind River Systems, Inc.

LICENSE = "Apache-2.0"

ROS_BUILDTOOL_DEPENDS += " \
    rosidl-default-runtime-native \
"

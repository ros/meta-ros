# Copyright (c) 2025 Wind River Systems, Inc.

LICENSE = "BSD-3-Clause"

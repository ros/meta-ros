# Copyright (c) 2026 Wind River Systems, Inc.

# Metapackage without license text; licenses of imu_processors
# (BSD-3-Clause) and imu_transformer (GPL-3.0-only).
LICENSE = "BSD-3-Clause AND GPL-3.0-only"

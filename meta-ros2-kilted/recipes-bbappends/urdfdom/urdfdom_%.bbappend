# Copyright (c) 2020 LG Electronics, Inc.

inherit ros_insane_dev_so

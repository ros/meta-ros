# Copyright (c) 2026 Wind River Systems, Inc.

LICENSE = "MIT & BSD-3-Clause"

# Copyright (c) 2024 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += "gz-rendering9"

ROS_BUILDTOOL_DEPENDS += "cppcheck-native doxygen-native"

inherit ros_insane_dev_so

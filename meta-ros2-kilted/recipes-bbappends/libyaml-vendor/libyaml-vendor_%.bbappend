# Copyright (c) 2019-2021 LG Electronics, Inc.

DEPENDS += "libyaml"

inherit pkgconfig

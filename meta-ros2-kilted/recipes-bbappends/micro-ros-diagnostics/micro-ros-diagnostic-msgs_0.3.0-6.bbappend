# Copyright (c) 2021 LG Electronics, Inc.
# Copyright (c) 2023 Wind River Systems, Inc.

DEPENDS += "\
    rosidl-typesupport-fastrtps-c-native \
    rosidl-typesupport-fastrtps-cpp-native \
    std-msgs \
"

ROS_EXEC_DEPENDS += " \
    service-msgs \
"

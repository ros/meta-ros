# Copyright (c) 2024 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += " \
    service-msgs \
"

ROS_BUILDTOOL_DEPENDS += " \
    rosidl-default-runtime-native \
"

# Copyright (c) 2024 Wind River Systems, Inc.
LICENSE = "Apache-2.0"

ROS_BUILD_DEPENDS += " \
    rosidl-default-runtime \
"

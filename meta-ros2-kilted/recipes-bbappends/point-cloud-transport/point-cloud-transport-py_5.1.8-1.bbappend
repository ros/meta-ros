# Copyright (c) 2026 Wind River Systems, Inc.

LICENSE = "BSD-3-Clause & Apache-2.0"

inherit python3targetconfig

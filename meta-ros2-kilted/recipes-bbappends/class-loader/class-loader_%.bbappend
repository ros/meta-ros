# Copyright (c) 2023 Wind River Systems, Inc.
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e7df2cb5b828712253329843cc2d34ca"

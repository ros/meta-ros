# Copyright (c) 2023-2025 Wind River Systems, Inc.

LICENSE = "BSD-3-Clause"

ROS_BUILDTOOL_DEPENDS += " \
    rosidl-default-runtime-native \
"

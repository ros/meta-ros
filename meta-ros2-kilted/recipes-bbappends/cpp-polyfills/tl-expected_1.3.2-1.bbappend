# Converting from Creative-Commons-Zero-v1.0-Universal to SPDX conform CC0-1.0
LICENSE = "CC0-1.0"

# Copyright (c) 2026 Wind River Systems, Inc.

# package.xml declares "GPLv2+" but the source headers are Apache-2.0;
# the upstream repository ships both LICENSE (Apache-2.0) and
# LICENSE.gpl (GPL-2.0), so both are listed.
LICENSE = "Apache-2.0 & GPL-2.0-or-later"


# Copyright (c) 2024 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += "gz-plugin2"

inherit ros_insane_dev_so

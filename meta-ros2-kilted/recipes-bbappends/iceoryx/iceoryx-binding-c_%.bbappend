# Copyright (c) 2022 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += " \
    iceoryx-hoofs-native \
    iceoryx-posh-native \
"

# Copyright (c) 2023 Wind River Systems, Inc.

inherit pkgconfig

# Copyright (c) 2024 Wind River Systems, Inc.

LICENSE = "BSD-3-Clause"

FILES:${PN}-dev =+ "${ros_libdir}/lib*${SOLIBSDEV}"

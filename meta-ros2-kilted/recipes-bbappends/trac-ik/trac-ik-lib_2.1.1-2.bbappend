# Copyright (c) 2024 Wind River Systems, Inc.

inherit pkgconfig

LICENSE = "BSD-3-Clause"

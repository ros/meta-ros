# Copyright (c) 2021 LG Electronics, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    python3-empy-native \
"

LICENSE = "GPL-3.0-only & LGPL-3.0-only & BSD-3-Clause"

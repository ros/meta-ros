# Copyright (c) 2022-2024 Wind River Systems, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    generate-parameter-library-py-native \
    python3-pyyaml-native \
"

# Copyright (C) 2023 Advanced Micro Devices, Inc.  All rights reserved.

LICENSE = "BSD-3-Clause"

# Copyright (c) 2023 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += " \
    ament-cmake-gtest \
    googletest \
"

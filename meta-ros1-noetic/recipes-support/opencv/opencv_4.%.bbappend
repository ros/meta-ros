# Copyright (c) 2021 LG Electronics, Inc.

# required by meta-ros1-noetic/generated-recipes/dnn-detect/dnn-detect_0.1.0-1.bb
PACKAGECONFIG:append = " dnn"

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "Catkinized gRPC Package"
AUTHOR = "Shengye Wang <shengye@ucsd.edu>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "grpc"
ROS_BPN = "grpc"

ROS_BUILD_DEPENDS = " \
    autoconf \
    git \
    libtool \
    openssl \
    rsync \
    zlib \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    openssl \
    rsync \
    zlib \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    openssl \
    rsync \
    zlib \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/CogRobRelease/catkin_grpc-release/archive/release/noetic/grpc/0.0.16-2.tar.gz
ROS_BRANCH ?= "branch=release/noetic/grpc"
SRC_URI = "git://github.com/CogRobRelease/catkin_grpc-release;${ROS_BRANCH};protocol=https"
SRCREV = "e1293e68e52c8a8a28abdb29bb375af07182ae03"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

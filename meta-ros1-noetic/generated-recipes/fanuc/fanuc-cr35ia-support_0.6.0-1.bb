# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "<p>       ROS-Industrial support for the Fanuc CR-35iA (and variants).     </p>     <p>       This package contains configuration data, 3D models and launch files       for Fanuc CR-35iA manipulators. This currently includes the base model       only.     </p>     <p><b>Specifications</b>:</p>     <ul>       <li>CR-35iA - Normal Range</li>     </ul>     <p>       Joint limits and maximum joint velocities are based on the information in       the <em>FANUC Robot CR-35iA Mechanical Unit Operator's Manual</em> version       <em>B-83734EN/01</em>. All urdfs are based on the default motion and       joint velocity limits, unless noted otherwise (ie: no support for high       speed joints, extended / limited motion ranges or other options).     </p>     <p>       Before using any of the configuration files and / or meshes included       in this package, be sure to check they are correct for the particular       robot model and configuration you intend to use them with.     </p>     <p>       <b>Note</b>: there is currently some confusion over the correct values for       the joint limits of joints 2 and 3. Version <em>B-83734EN/01</em> of the       Operator's Manual incorrectly states that 1.05 rad equals 120 degrees,       and that 0.39 rad equals 45 degrees (joint 2). Additionally, it gives a       value of -122.9 degrees for the lower limit of joint 3, whereas (at       least) Roboguide Rev K have this limit set to -182 degrees.       We advise users to pay extra attention when verifying the xacro in this       support package until this is cleared up.     </p>"
AUTHOR = "G.A. vd. Hoorn (TU Delft Robotics Institute) <g.a.vanderhoorn@tudelft.nl>"
ROS_AUTHOR = "G.A. vd. Hoorn (TU Delft Robotics Institute)"
HOMEPAGE = "http://wiki.ros.org/fanuc_cr35ia_support"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=44;endline=44;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "fanuc"
ROS_BPN = "fanuc_cr35ia_support"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    fanuc-driver \
    fanuc-resources \
    industrial-robot-client \
    joint-state-publisher-gui \
    robot-state-publisher \
    rviz \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    roslaunch \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros-industrial-release/fanuc-release/archive/release/noetic/fanuc_cr35ia_support/0.6.0-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/fanuc_cr35ia_support"
SRC_URI = "git://github.com/ros-industrial-release/fanuc-release;${ROS_BRANCH};protocol=https"
SRCREV = "bfd8f71f8e00aab76c8520c7f5195f7cfdca1425"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

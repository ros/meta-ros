# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "MassRobotics AMR Interop Sender"
AUTHOR = "InOrbit <support@inorbit.ai>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "3-Clause BSD License"
LICENSE = "3-Clause-BSD-License"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=b2936c3d94155c5964d05e132190fe1d"

ROS_CN = "ros_amr_interop"
ROS_BPN = "massrobotics_amr_sender"

ROS_BUILD_DEPENDS = " \
    geometry-msgs \
    nav-msgs \
    rospy \
    sensor-msgs \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    geometry-msgs \
    nav-msgs \
    rospy \
    sensor-msgs \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    geometry-msgs \
    nav-msgs \
    python3-pykdl \
    python3-websockets \
    rospy \
    sensor-msgs \
    std-msgs \
    tf2-kdl \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    python3-jsonschema \
    python3-mock \
    python3-pep8 \
    python3-pytest \
    python3-pytest-mock \
    python3-pyyaml \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/inorbit-ai/ros_amr_interop-release/archive/release/noetic/massrobotics_amr_sender/1.0.1-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/massrobotics_amr_sender"
SRC_URI = "git://github.com/inorbit-ai/ros_amr_interop-release;${ROS_BRANCH};protocol=https"
SRCREV = "5fc8c5ae05eca8aff8c373c4f88f6408fe588d96"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

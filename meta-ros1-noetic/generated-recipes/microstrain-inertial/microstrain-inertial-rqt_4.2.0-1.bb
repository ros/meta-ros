# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "The microstrain_inertial_rqt package provides several RQT widgets to view the status of Microstrain devices"
AUTHOR = "Rob Fisher <rob.fisher@parker.com>"
ROS_AUTHOR = "Parker Hannifin Corp"
HOMEPAGE = "https://github.com/LORD-MicroStrain/microstrain_inertial"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "microstrain_inertial"
ROS_BPN = "microstrain_inertial_rqt"

ROS_BUILD_DEPENDS = " \
    geometry-msgs \
    microstrain-inertial-msgs \
    nav-msgs \
    rospy \
    rqt-gui \
    rqt-gui-py \
    std-msgs \
    tf \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    geometry-msgs \
    microstrain-inertial-msgs \
    nav-msgs \
    rospy \
    rqt-gui \
    rqt-gui-py \
    std-msgs \
    tf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    geometry-msgs \
    microstrain-inertial-msgs \
    nav-msgs \
    rospy \
    rqt-gui \
    rqt-gui-py \
    std-msgs \
    tf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/LORD-MicroStrain/microstrain_inertial-release/archive/release/noetic/microstrain_inertial_rqt/4.2.0-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/microstrain_inertial_rqt"
SRC_URI = "git://github.com/LORD-MicroStrain/microstrain_inertial-release;${ROS_BRANCH};protocol=https"
SRCREV = "3b0e9a7181c00285934ac10ea1fad5ee4aea6eee"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

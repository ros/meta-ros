# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "rqt GUI for rosbag_fancy"
AUTHOR = "Max Schwarz <max.schwarz@ais.uni-bonn.de>"
ROS_AUTHOR = "Christian Lenz <lenz@ais.uni-bonn.de>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=5;endline=5;md5=75730354549103aaba72b66caf53717b"

ROS_CN = "rosbag_fancy"
ROS_BPN = "rqt_rosbag_fancy"

ROS_BUILD_DEPENDS = " \
    qtbase \
    rosbag-fancy-msgs \
    rosfmt \
    rqt-gui \
    rqt-gui-cpp \
    std-srvs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    rosbag-fancy-msgs \
    rosfmt \
    rqt-gui \
    rqt-gui-cpp \
    std-srvs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    rosbag-fancy-msgs \
    rosfmt \
    rqt-gui \
    rqt-gui-cpp \
    std-srvs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/xqms/rosbag_fancy-release/archive/release/noetic/rqt_rosbag_fancy/1.1.0-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/rqt_rosbag_fancy"
SRC_URI = "git://github.com/xqms/rosbag_fancy-release;${ROS_BRANCH};protocol=https"
SRCREV = "2ee0d37db3cfcd67382fa9c7db361e6e27f4e24b"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

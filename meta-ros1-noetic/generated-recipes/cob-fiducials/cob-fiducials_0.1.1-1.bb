# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "Fiducial recognition. Implementation of different 2D tags like PI-tag from Bergamasco et al. for recognition with a single 2D camera."
AUTHOR = "Richard Bormann <richard.bormann@ipa.fraunhofer.de>"
ROS_AUTHOR = "Jan Fischer"
HOMEPAGE = "http://ros.org/wiki/cob_fiducials"
SECTION = "devel"
LICENSE = "LGPL"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=46ee8693f40a89a31023e97ae17ecf19"

ROS_CN = "cob_fiducials"
ROS_BPN = "cob_fiducials"

ROS_BUILD_DEPENDS = " \
    boost \
    cmake-modules \
    cob-object-detection-msgs \
    cob-vision-utils \
    cv-bridge \
    diagnostic-msgs \
    diagnostic-updater \
    image-transport \
    libtinyxml \
    opencv \
    roscpp \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    boost \
    cmake-modules \
    cob-object-detection-msgs \
    cob-vision-utils \
    cv-bridge \
    diagnostic-msgs \
    diagnostic-updater \
    image-transport \
    libtinyxml \
    opencv \
    roscpp \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    boost \
    cmake-modules \
    cob-object-detection-msgs \
    cob-vision-utils \
    cv-bridge \
    diagnostic-msgs \
    diagnostic-updater \
    image-transport \
    libtinyxml \
    opencv \
    roscpp \
    rospy \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/4am-robotics/cob_fiducials-release/archive/release/noetic/cob_fiducials/0.1.1-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/cob_fiducials"
SRC_URI = "git://github.com/4am-robotics/cob_fiducials-release;${ROS_BRANCH};protocol=https"
SRCREV = "cf399b38b8ddbb2af71405ac42bce95f9f9c4144"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

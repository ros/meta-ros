# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "Darknet is an open source neural network framework that runs on CPU and GPU. You only look once (YOLO) is a state-of-the-art, real-time object detection system."
AUTHOR = "Marko Bjelonic <marko.bjelonic@mavt.ethz.ch>"
ROS_AUTHOR = "Marko Bjelonic <marko.bjelonic@mavt.ethz.ch>"
HOMEPAGE = "https://github.com/leggedrobotics/darknet_ros"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "darknet_ros"
ROS_BPN = "darknet_ros"

ROS_BUILD_DEPENDS = " \
    actionlib \
    boost \
    cv-bridge \
    darknet-ros-msgs \
    image-transport \
    libx11 \
    libxext \
    libxt \
    message-generation \
    nodelet \
    opencv \
    roscpp \
    rospy \
    sensor-msgs \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    actionlib \
    boost \
    cv-bridge \
    darknet-ros-msgs \
    image-transport \
    libx11 \
    libxext \
    libxt \
    message-generation \
    nodelet \
    opencv \
    roscpp \
    rospy \
    sensor-msgs \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    actionlib \
    boost \
    cv-bridge \
    darknet-ros-msgs \
    image-transport \
    libx11 \
    libxext \
    libxt \
    message-generation \
    nodelet \
    opencv \
    roscpp \
    rospy \
    sensor-msgs \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    rostest \
    wget \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/leggedrobotics/darknet_ros-release/archive/release/noetic/darknet_ros/1.1.5-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/darknet_ros"
SRC_URI = "git://github.com/leggedrobotics/darknet_ros-release;${ROS_BRANCH};protocol=https"
SRCREV = "9f448396ffa31cb6e4383de6205ac4025436fdf3"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

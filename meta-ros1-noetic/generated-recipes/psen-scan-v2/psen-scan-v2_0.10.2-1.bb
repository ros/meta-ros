# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "ROS support for the Pilz laser scanner"
AUTHOR = "Alexander Gutenkunst <a.gutenkunst@pilz.de>"
ROS_AUTHOR = "Pilz GmbH + Co. KG"
HOMEPAGE = "https://github.com/PilzDE/psen_scan_v2/issues"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "LGPLv3"
LICENSE = "LGPL-3.0-only"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=b691248d2f70cdaeeaf13696ada5d47c"

ROS_CN = "psen_scan_v2"
ROS_BPN = "psen_scan_v2"

ROS_BUILD_DEPENDS = " \
    cmake-modules \
    fmt \
    geometry-msgs \
    libtinyxml2 \
    message-generation \
    rosconsole-bridge \
    roscpp \
    sensor-msgs \
    std-msgs \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    fmt \
    geometry-msgs \
    libtinyxml2 \
    rosconsole-bridge \
    roscpp \
    sensor-msgs \
    std-msgs \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    fmt \
    geometry-msgs \
    libtinyxml2 \
    message-runtime \
    robot-state-publisher \
    rosconsole-bridge \
    roscpp \
    roslaunch \
    rviz \
    sensor-msgs \
    std-msgs \
    visualization-msgs \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    code-coverage \
    rosbag \
    roslaunch \
    rostest \
    rosunit \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/PilzDE/psen_scan_v2-release/archive/release/noetic/psen_scan_v2/0.10.2-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/psen_scan_v2"
SRC_URI = "git://github.com/PilzDE/psen_scan_v2-release;${ROS_BRANCH};protocol=https"
SRCREV = "55433af00f6e13f5c15d7b35fcc5e624dcb47ad0"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

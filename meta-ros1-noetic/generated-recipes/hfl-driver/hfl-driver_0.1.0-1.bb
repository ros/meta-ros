# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "The hfl package"
AUTHOR = "Evan Flynn <evan.flynn@continental.com>"
ROS_AUTHOR = "Evan Flynn <evan.flynn@continental.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "hfl_driver"
ROS_BPN = "hfl_driver"

ROS_BUILD_DEPENDS = " \
    angles \
    camera-info-manager \
    cv-bridge \
    diagnostic-updater \
    dynamic-reconfigure \
    image-geometry \
    image-transport \
    nodelet \
    roscpp \
    rospy \
    sensor-msgs \
    std-msgs \
    tf \
    tf2 \
    tf2-geometry-msgs \
    udp-com \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    angles \
    camera-info-manager \
    cv-bridge \
    diagnostic-updater \
    dynamic-reconfigure \
    geometry-msgs \
    image-geometry \
    image-transport \
    nodelet \
    roscpp \
    rospy \
    sensor-msgs \
    std-msgs \
    tf \
    tf2 \
    tf2-geometry-msgs \
    udp-com \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    angles \
    camera-info-manager \
    cv-bridge \
    diagnostic-updater \
    dynamic-reconfigure \
    geometry-msgs \
    image-geometry \
    image-transport \
    message-runtime \
    nodelet \
    roscpp \
    rospy \
    sensor-msgs \
    std-msgs \
    tf \
    tf2 \
    tf2-geometry-msgs \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    roslint \
    rostest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/flynneva/hfl_driver-release/archive/release/noetic/hfl_driver/0.1.0-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/hfl_driver"
SRC_URI = "git://github.com/flynneva/hfl_driver-release;${ROS_BRANCH};protocol=https"
SRCREV = "75b1e1f4a5506c335adaac47b7e243f8374107a6"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "The frame_editor package"
AUTHOR = "ipa-lth <lorenz.halt@ipa.fraunhofer.de>"
ROS_AUTHOR = "ipa-lth <lorenz.halt@ipa.fraunhofer.de>"
HOMEPAGE = "http://www.ipa.fraunhofer.de/"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=2c00b8d2854109dbebef7818b4dae1e2"

ROS_CN = "frame_editor"
ROS_BPN = "frame_editor"

ROS_BUILD_DEPENDS = " \
    dynamic-reconfigure \
    geometry-msgs \
    interactive-markers \
    message-generation \
    rospy \
    rqt-gui \
    rqt-gui-py \
    std-msgs \
    tf \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    dynamic-reconfigure \
    geometry-msgs \
    interactive-markers \
    message-runtime \
    rospy \
    rqt-gui \
    rqt-gui-py \
    std-msgs \
    tf \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    dynamic-reconfigure \
    geometry-msgs \
    interactive-markers \
    message-runtime \
    qt-gui-py-common \
    rospy \
    rqt-gui \
    rqt-gui-py \
    std-msgs \
    tf \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ipa320/rqt_frame_editor_plugin-release/archive/release/noetic/frame_editor/1.2.0-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/frame_editor"
SRC_URI = "git://github.com/ipa320/rqt_frame_editor_plugin-release;${ROS_BRANCH};protocol=https"
SRCREV = "30aa7b98bd3b656309c5df0d8e800f0e9d8a122f"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

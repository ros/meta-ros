# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "A radar-like visualization for humans in the scene, representing their position, orientation, engagement level"
AUTHOR = "Lorenzo Ferrini <lorenzo.ferrini@pal-robotics.com>"
ROS_AUTHOR = "Lorenzo Ferrini <lorenzo.ferrini@pal-robotics.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "rqt_human_radar"
ROS_BPN = "rqt_human_radar"

ROS_BUILD_DEPENDS = " \
    hri \
    qtbase \
    qtsvg \
    roscpp \
    rqt-gui \
    rqt-gui-cpp \
    tf \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    hri \
    qtbase \
    qtsvg \
    rqt-gui \
    rqt-gui-cpp \
    tf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    hri \
    qtbase \
    qtsvg \
    rqt-gui \
    rqt-gui-cpp \
    tf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros4hri/rqt_human_radar-release/archive/release/noetic/rqt_human_radar/0.2.1-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/rqt_human_radar"
SRC_URI = "git://github.com/ros4hri/rqt_human_radar-release;${ROS_BRANCH};protocol=https"
SRCREV = "bbb2730fc16d4b22b0bcdf42e2f6af151ffb4170"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "<p>Metapackage that contains commonly used 3rdparty toolset for jsk-ros-pkg</p>"
AUTHOR = "Kei Okada <k-okada@jsk.t.u-tokyo.ac.jp>"
ROS_AUTHOR = "Kei Okada <k-okada@jsk.t.u-tokyo.ac.jp>"
HOMEPAGE = "http://ros.org/wiki/jsk_3rdparty"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "jsk_3rdparty"
ROS_BPN = "jsk_3rdparty"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    aques-talk \
    assimp-devel \
    bayesian-belief-networks \
    chaplus-ros \
    dialogflow-task-executive \
    downward \
    emotion-analyzer \
    ff \
    ffha \
    gdrive-ros \
    google-chat-ros \
    google-cloud-texttospeech \
    influxdb-store \
    julius \
    julius-ros \
    libcmt \
    libsiftfast \
    lpg-planner \
    mini-maxwell \
    nfc-ros \
    opt-camera \
    osqp \
    pgm-learner \
    respeaker-ros \
    ros-google-cloud-language \
    ros-speech-recognition \
    rospatlite \
    rosping \
    rostwitter \
    sesame-ros \
    switchbot-ros \
    voicevox \
    webrtcvad-ros \
    zdepth \
    zdepth-image-transport \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    aques-talk \
    assimp-devel \
    bayesian-belief-networks \
    chaplus-ros \
    dialogflow-task-executive \
    downward \
    emotion-analyzer \
    ff \
    ffha \
    gdrive-ros \
    google-chat-ros \
    google-cloud-texttospeech \
    influxdb-store \
    julius \
    julius-ros \
    libcmt \
    libsiftfast \
    lpg-planner \
    mini-maxwell \
    nfc-ros \
    opt-camera \
    osqp \
    pgm-learner \
    respeaker-ros \
    ros-google-cloud-language \
    ros-speech-recognition \
    rospatlite \
    rosping \
    rostwitter \
    sesame-ros \
    switchbot-ros \
    voicevox \
    webrtcvad-ros \
    zdepth \
    zdepth-image-transport \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/tork-a/jsk_3rdparty-release/archive/release/noetic/jsk_3rdparty/2.1.31-4.tar.gz
ROS_BRANCH ?= "branch=release/noetic/jsk_3rdparty"
SRC_URI = "git://github.com/tork-a/jsk_3rdparty-release;${ROS_BRANCH};protocol=https"
SRCREV = "3b3dcbd90d1d6a505bbf90a10c789fb1049acd2a"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "Eclipse Paho MQTT C++ Client Library"
AUTHOR = "Tim Clephas <tim.clephas@nobleo.nl>"
HOMEPAGE = "https://github.com/eclipse/paho.mqtt.cpp.git"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Eclipse Public License - v 1.0"
LICENSE = "Eclipse-Public-License-v-1.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=72a574969ac4609134c7d3ea021e7097"

ROS_CN = "paho-mqtt-cpp"
ROS_BPN = "paho-mqtt-cpp"

ROS_BUILD_DEPENDS = " \
    openssl \
    paho-mqtt-c \
"

ROS_BUILDTOOL_DEPENDS = " \
    cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    openssl \
    paho-mqtt-c \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    openssl \
    paho-mqtt-c \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/nobleo/paho.mqtt.cpp-release/archive/release/noetic/paho-mqtt-cpp/1.3.1-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/paho-mqtt-cpp"
SRC_URI = "git://github.com/nobleo/paho.mqtt.cpp-release;${ROS_BRANCH};protocol=https"
SRCREV = "d2a60ca62fc3d1ee6fff0db6cbdd82a3674e45f4"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "An open-source version of the Fetch charge docking system."
AUTHOR = "Sarah Elliott <selliott@fetchrobotics.com>"
ROS_AUTHOR = "Michael Ferguson"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "LGPLv3"
LICENSE = "LGPL-3.0-only"
LIC_FILES_CHKSUM = "file://package.xml;beginline=17;endline=17;md5=b691248d2f70cdaeeaf13696ada5d47c"

ROS_CN = "fetch_open_auto_dock"
ROS_BPN = "fetch_open_auto_dock"

ROS_BUILD_DEPENDS = " \
    actionlib \
    angles \
    fetch-auto-dock-msgs \
    fetch-driver-msgs \
    geometry-msgs \
    libeigen \
    nav-msgs \
    roscpp \
    roslib \
    rospy \
    sensor-msgs \
    std-msgs \
    tf \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    actionlib \
    fetch-auto-dock-msgs \
    fetch-driver-msgs \
    geometry-msgs \
    libeigen \
    nav-msgs \
    roscpp \
    roslib \
    rospy \
    sensor-msgs \
    std-msgs \
    tf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    actionlib \
    fetch-auto-dock-msgs \
    fetch-driver-msgs \
    geometry-msgs \
    libeigen \
    nav-msgs \
    roscpp \
    roslib \
    rospy \
    sensor-msgs \
    std-msgs \
    tf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/fetchrobotics-gbp/fetch_open_auto_dock-gbp/archive/release/noetic/fetch_open_auto_dock/0.1.3-2.tar.gz
ROS_BRANCH ?= "branch=release/noetic/fetch_open_auto_dock"
SRC_URI = "git://github.com/fetchrobotics-gbp/fetch_open_auto_dock-gbp;${ROS_BRANCH};protocol=https"
SRCREV = "2b8d1ba05a1f3a06f37837bbb7d35a2bec79f7d8"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "Depthai ROS Monolithic node."
AUTHOR = "Adam Serafin <adam.serafin@luxonis.com>"
ROS_AUTHOR = "Adam Serafin"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "depthai-ros"
ROS_BPN = "depthai_ros_driver"

ROS_BUILD_DEPENDS = " \
    camera-info-manager \
    cv-bridge \
    depthai \
    depthai-bridge \
    depthai-descriptions \
    depthai-examples \
    depthai-ros-msgs \
    diagnostic-msgs \
    diagnostic-updater \
    dynamic-reconfigure \
    image-pipeline \
    image-transport \
    image-transport-plugins \
    message-filters \
    nodelet \
    pluginlib \
    roscpp \
    rospy \
    sensor-msgs \
    std-msgs \
    std-srvs \
    vision-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    camera-info-manager \
    cv-bridge \
    depthai \
    depthai-bridge \
    depthai-descriptions \
    depthai-examples \
    depthai-ros-msgs \
    diagnostic-msgs \
    diagnostic-updater \
    dynamic-reconfigure \
    image-pipeline \
    image-transport \
    image-transport-plugins \
    message-filters \
    nodelet \
    pluginlib \
    roscpp \
    rospy \
    sensor-msgs \
    std-msgs \
    std-srvs \
    vision-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    camera-info-manager \
    cv-bridge \
    depthai \
    depthai-bridge \
    depthai-descriptions \
    depthai-examples \
    depthai-ros-msgs \
    diagnostic-msgs \
    diagnostic-updater \
    dynamic-reconfigure \
    image-pipeline \
    image-transport \
    image-transport-plugins \
    message-filters \
    nodelet \
    pluginlib \
    roscpp \
    rospy \
    sensor-msgs \
    std-msgs \
    std-srvs \
    vision-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/luxonis/depthai-ros-release/archive/release/noetic/depthai_ros_driver/2.9.0-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/depthai_ros_driver"
SRC_URI = "git://github.com/luxonis/depthai-ros-release;${ROS_BRANCH};protocol=https"
SRCREV = "78eb4c66e94962c5c1e55a8f05e90137886c21b3"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

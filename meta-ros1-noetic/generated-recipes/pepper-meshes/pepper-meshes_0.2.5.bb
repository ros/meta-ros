# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "meshes for the Aldebaran Robotics Pepper"
AUTHOR = "Maxime Busy <mbusy@softbankrobotics.com>"
ROS_AUTHOR = "Vincent Rabaud <vincent.rabaud@gmail.com>"
HOMEPAGE = "http://github.com/ros-naoqi/pepper_meshes/"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Creative Commons Attribution-NonCommercial-NoDerivatives 4.0 International Public License"
LICENSE = "CC-BY-NC-ND-4.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=cc423ec78844eb7f9a98d5df4d0f6289"

ROS_CN = "pepper_meshes"
ROS_BPN = "pepper_meshes"

ROS_BUILD_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-java} \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = ""

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros-naoqi/pepper_meshes-release/archive/release/noetic/pepper_meshes/0.2.5-0.tar.gz
ROS_BRANCH ?= "branch=release/noetic/pepper_meshes"
SRC_URI = "git://github.com/ros-naoqi/pepper_meshes-release;${ROS_BRANCH};protocol=https"
SRCREV = "49779062de9df6caf9008c61f5e4f3a83ed857a7"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

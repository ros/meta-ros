# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "grep for ROS bag files and live topics"
AUTHOR = "Erki Suurjaak <erki@lap.ee>"
ROS_AUTHOR = "Erki Suurjaak <erki@lap.ee>"
HOMEPAGE = "http://www.ros.org/wiki/grepros"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "grepros"
ROS_BPN = "grepros"

ROS_BUILD_DEPENDS = " \
    genpy \
    python3-pyyaml \
    rosbag \
    roslib \
    rospy \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    genpy \
    python3-pyyaml \
    rosbag \
    roslib \
    rospy \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    genpy \
    python3-pyyaml \
    rosbag \
    roslib \
    rospy \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    rostest \
    std-msgs \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/suurjaak/grepros-release/archive/release/noetic/grepros/0.4.7-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/grepros"
SRC_URI = "git://github.com/suurjaak/grepros-release;${ROS_BRANCH};protocol=https"
SRCREV = "ffeee111143740a23ceed63905085ace2ec31539"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

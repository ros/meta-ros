# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "EusLisp software developed and used by JSK at The University of Tokyo"
AUTHOR = "Kei Okada <k-okada@jsk.t.u-tokyo.ac.jp>"
ROS_AUTHOR = "JSK Alumnis"
HOMEPAGE = "http://euslisp.github.io/jskeus/manual.html"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "jskeus"
ROS_BPN = "jskeus"

ROS_BUILD_DEPENDS = " \
    euslisp \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    euslisp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    euslisp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/tork-a/jskeus-release/archive/release/noetic/jskeus/1.2.5-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/jskeus"
SRC_URI = "git://github.com/tork-a/jskeus-release;${ROS_BRANCH};protocol=https"
SRCREV = "2527fdbf47c7169be2644b0a8fd58b11d260622b"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

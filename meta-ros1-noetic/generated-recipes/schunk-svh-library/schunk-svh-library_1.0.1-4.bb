# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "Standalone C++ library for accessing the Schunk five finger hand."
AUTHOR = "Stefan Scherzinger <scherzin@fzi.de>"
ROS_AUTHOR = "Georg Heppner"
HOMEPAGE = "http://wiki.ros.org/schunk_svh_library"
SECTION = "devel"
LICENSE = "GPL-3.0-or-later"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=5f660bce20dfd88ba2749c28f85619d4"

ROS_CN = "schunk_svh_library"
ROS_BPN = "schunk_svh_library"

ROS_BUILD_DEPENDS = " \
    boost \
"

ROS_BUILDTOOL_DEPENDS = " \
    cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    catkin \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    boost \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/SCHUNK-GmbH-Co-KG/schunk_svh_library-release/archive/release/noetic/schunk_svh_library/1.0.1-4.tar.gz
ROS_BRANCH ?= "branch=release/noetic/schunk_svh_library"
SRC_URI = "git://github.com/SCHUNK-GmbH-Co-KG/schunk_svh_library-release;${ROS_BRANCH};protocol=https"
SRCREV = "5d9854ac8b86e8b36e727bac1bb26bbd928dab24"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

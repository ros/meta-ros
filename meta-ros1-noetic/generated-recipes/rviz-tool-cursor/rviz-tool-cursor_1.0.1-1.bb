# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "The rviz_tool_cursor package"
AUTHOR = "Michael Ripperger <michael.ripperger@swri.org>"
ROS_AUTHOR = "Michael Ripperger <michael.ripperger@swri.org>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=3dce4ba60d7e51ec64f3c3dc18672dd3"

ROS_CN = "rviz_tool_cursor"
ROS_BPN = "rviz_tool_cursor"

ROS_BUILD_DEPENDS = " \
    libeigen \
    pluginlib \
    qtbase \
    rviz \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    pluginlib \
    qtbase \
    rviz \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    pluginlib \
    qtbase \
    rviz \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros-industrial-release/rviz_tool_cursor/archive/release/noetic/rviz_tool_cursor/1.0.1-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/rviz_tool_cursor"
SRC_URI = "git://github.com/ros-industrial-release/rviz_tool_cursor;${ROS_BRANCH};protocol=https"
SRCREV = "6ecdf810f3de9564e9a09827ea34c0109ff01401"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

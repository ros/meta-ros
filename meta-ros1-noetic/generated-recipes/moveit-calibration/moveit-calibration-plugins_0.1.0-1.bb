# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "Plugins of MoveIt calibration"
AUTHOR = "Yu Yan <yu.yan@intel.com>"
ROS_AUTHOR = "Yu Yan <yu.yan@intel.com>"
HOMEPAGE = "http://moveit.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "moveit_calibration"
ROS_BPN = "moveit_calibration_plugins"

ROS_BUILD_DEPENDS = " \
    jsoncpp \
    libeigen \
    pluginlib \
    rosconsole \
    roscpp \
    sensor-msgs \
    tf2 \
    tf2-eigen \
    tf2-geometry-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    jsoncpp \
    pluginlib \
    rosconsole \
    roscpp \
    sensor-msgs \
    tf2 \
    tf2-eigen \
    tf2-geometry-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    baldor \
    criutils \
    handeye \
    jsoncpp \
    pluginlib \
    rosconsole \
    roscpp \
    sensor-msgs \
    tf2 \
    tf2-eigen \
    tf2-geometry-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    rosunit \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/JStech/moveit_calibration-release/archive/release/noetic/moveit_calibration_plugins/0.1.0-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/moveit_calibration_plugins"
SRC_URI = "git://github.com/JStech/moveit_calibration-release;${ROS_BRANCH};protocol=https"
SRCREV = "53e36183a2cb7fcea73257c51d22e24f7d159800"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "Ignition ros_control package demos."
AUTHOR = "graiola <gennaro.raiola@gmail.com>"
ROS_AUTHOR = "Gennaro Raiola"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache 2"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=fc216ef9336537897fbeafa564601763"

ROS_CN = "ign_ros_control"
ROS_BPN = "ign_ros_control_demos"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
    python3-setuptools-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    effort-controllers \
    ign-ros-control \
    joint-state-controller \
    joint-state-publisher \
    position-controllers \
    ros-ign-gazebo \
    velocity-controllers \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros-gbp/ign_ros_control-release/archive/release/noetic/ign_ros_control_demos/0.0.1-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/ign_ros_control_demos"
SRC_URI = "git://github.com/ros-gbp/ign_ros_control-release;${ROS_BRANCH};protocol=https"
SRCREV = "61d16a7a8ade0e87dae07d69793f7c8448ff2676"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "The gpp_plugin package offers a pipeline for running global    planners together with auxiliary pre- and post-processing functions"
AUTHOR = "Dima Dorezyuk <dmitrij.dorezyuk@hotmail.de>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "gpp"
ROS_BPN = "gpp_plugin"

ROS_BUILD_DEPENDS = " \
    costmap-2d \
    gpp-interface \
    mbf-costmap-core \
    mbf-msgs \
    nav-core \
    pluginlib \
    xmlrpcpp \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    costmap-2d \
    gpp-interface \
    mbf-costmap-core \
    mbf-msgs \
    nav-core \
    pluginlib \
    xmlrpcpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    costmap-2d \
    gpp-interface \
    mbf-costmap-core \
    mbf-msgs \
    nav-core \
    pluginlib \
    xmlrpcpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    global-planner \
    mbf-costmap-nav \
    move-base \
    rostest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/dorezyuk/gpp-release/archive/release/noetic/gpp_plugin/0.1.0-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/gpp_plugin"
SRC_URI = "git://github.com/dorezyuk/gpp-release;${ROS_BRANCH};protocol=https"
SRCREV = "64e2f297b144be7836be9b87a1ebb75717264ff2"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

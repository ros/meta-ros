# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "A generic Lidar SLAM package based on FLOAM which was based on ALOAM by HKUST and LOAM by CMU"
AUTHOR = "Evan Flynn <evanflynn.msu@gmail.com>"
ROS_AUTHOR = "Han Wang <wh200720041@gmail.com>"
HOMEPAGE = "https://wanghan.pro"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "floam"
ROS_BPN = "floam"

ROS_BUILD_DEPENDS = " \
    ceres-solver \
    eigen-conversions \
    geometry-msgs \
    hector-trajectory-server \
    libeigen \
    nav-msgs \
    nodelet \
    pcl \
    pcl-ros \
    rosbag \
    roscpp \
    rospy \
    sensor-msgs \
    std-msgs \
    tf2 \
    tf2-geometry-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    ceres-solver \
    eigen-conversions \
    geometry-msgs \
    hector-trajectory-server \
    libeigen \
    nav-msgs \
    nodelet \
    pcl \
    pcl-ros \
    rosbag \
    roscpp \
    rospy \
    sensor-msgs \
    std-msgs \
    tf2 \
    tf2-geometry-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ceres-solver \
    eigen-conversions \
    geometry-msgs \
    hector-trajectory-server \
    libeigen \
    nav-msgs \
    nodelet \
    pcl \
    pcl-ros \
    rosbag \
    roscpp \
    rospy \
    sensor-msgs \
    std-msgs \
    tf2 \
    tf2-geometry-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/flynneva/floam-release/archive/release/noetic/floam/0.1.0-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/floam"
SRC_URI = "git://github.com/flynneva/floam-release;${ROS_BRANCH};protocol=https"
SRCREV = "9fdc9f40a45e6e1de5efabf4caa30910d097e50f"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_noetic
inherit ros_superflore_generated

DESCRIPTION = "gazebo_ros_contrl_select_joints"
AUTHOR = "Stefan Fabian <fabian@sim.tu-darmstadt.de>"
ROS_AUTHOR = "Jonathan Bohren"
HOMEPAGE = "http://ros.org/wiki/gazebo_ros_control_select_joints"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "gazebo_ros_control_select_joints"
ROS_BPN = "gazebo_ros_control_select_joints"

ROS_BUILD_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-gazebo} \
    angles \
    control-toolbox \
    controller-manager \
    gazebo-ros-control \
    hardware-interface \
    joint-limits-interface \
    pluginlib \
    roscpp \
    std-msgs \
    transmission-interface \
    urdf \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-gazebo} \
    angles \
    control-toolbox \
    controller-manager \
    gazebo-ros \
    gazebo-ros-control \
    hardware-interface \
    joint-limits-interface \
    pluginlib \
    roscpp \
    std-msgs \
    transmission-interface \
    urdf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-gazebo} \
    angles \
    control-toolbox \
    controller-manager \
    gazebo-ros \
    gazebo-ros-control \
    hardware-interface \
    joint-limits-interface \
    pluginlib \
    roscpp \
    std-msgs \
    transmission-interface \
    urdf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/tu-darmstadt-ros-pkg-gbp/gazebo_ros_control_select_joints-release/archive/release/noetic/gazebo_ros_control_select_joints/2.5.7-1.tar.gz
ROS_BRANCH ?= "branch=release/noetic/gazebo_ros_control_select_joints"
SRC_URI = "git://github.com/tu-darmstadt-ros-pkg-gbp/gazebo_ros_control_select_joints-release;${ROS_BRANCH};protocol=https"
SRCREV = "dbaf2662440b709f0257e1f128726ff15d694c92"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

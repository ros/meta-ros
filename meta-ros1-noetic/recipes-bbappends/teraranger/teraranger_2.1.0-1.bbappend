# Copyright (c) 2020 LG Electronics, Inc.

FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
SRC_URI += " \
    file://0001-scripts-evo_64px.py-cfg-EvoThermal.cfg-cfg-Evo64px.c.patch \
"

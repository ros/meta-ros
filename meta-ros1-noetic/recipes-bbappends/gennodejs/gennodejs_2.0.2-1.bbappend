EXTRA_OECMAKE:append = " -DCMAKE_POLICY_VERSION_MINIMUM=3.5"

INSANE_SKIP:${PN}-dev += "buildpaths"

# Copyright (c) 2021 LG Electronics, Inc.

DEPENDS += "python3-future-native python3-lxml-native"

inherit python3native

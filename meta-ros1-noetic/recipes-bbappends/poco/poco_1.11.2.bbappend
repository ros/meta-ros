SRC_URI = " \
    git://github.com/pocoproject/poco.git;branch=main;protocol=https \
    file://run-ptest \
   "

# Copyright (c) 2020 LG Electronics, Inc.

# Depends on libreflexxestype2 with this restriction
COMPATIBLE_MACHINE = "(^$)"
COMPATIBLE_MACHINE_x86-64 = "(.*)"

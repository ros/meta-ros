# package.xml declares "GPL", which is not a valid license identifier.
# Upstream check: source headers: polar_match is GPL v2 or later, psm_node GPL v3 or later.
LICENSE = "GPL-2.0-or-later & GPL-3.0-or-later"

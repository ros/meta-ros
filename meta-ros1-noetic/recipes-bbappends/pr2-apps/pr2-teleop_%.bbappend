# package.xml declares "TODO-CATKIN-PACKAGE-LICENSE", which is not a valid license identifier.
# Upstream check: source headers are BSD-3-Clause (package.xml has a TODO placeholder).
LICENSE = "BSD-3-Clause"

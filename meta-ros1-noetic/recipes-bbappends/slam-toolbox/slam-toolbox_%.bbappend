# package.xml declares "LGPL", which is not a valid license identifier.
# Upstream check: upstream LICENSE is LGPL v2.1; the bundled karto_sdk is LGPL v3.
LICENSE = "LGPL-2.1-only & LGPL-3.0-only"

# package.xml declares "LGPL", which is not a valid license identifier.
# Upstream check: upstream LICENSE is LGPL v2.1.
LICENSE = "LGPL-2.1-only"

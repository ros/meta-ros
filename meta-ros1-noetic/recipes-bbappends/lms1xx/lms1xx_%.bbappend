# package.xml declares "LGPL", which is not a valid license identifier.
# Upstream check: source headers are LGPL v2.1 or later.
LICENSE = "LGPL-2.1-or-later"

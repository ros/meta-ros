# package.xml declares "BSD-&-LGPL-&-Apache-2.0", which is not a valid license identifier.
# Upstream check: package.xml lists BSD, LGPL (no version found) and Apache 2.0.
LICENSE = "BSD-3-Clause & LGPL-2.0-or-later & Apache-2.0"

# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[flatbuffers] ?= "It is a fork of https://github.com/google/flatbuffers that's not used by any other ROS 1 package."

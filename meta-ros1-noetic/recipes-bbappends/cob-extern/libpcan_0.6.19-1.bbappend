# Copyright (c) 2020 LG Electronics, Inc.

# ERROR: libpcan-0.6.15-1-r0 do_package_qa: QA Issue: non -dev/-dbg/nativesdk- package contains symlink .so: libpcan path '/work/aarch64-oe-linux/libpcan/0.6.15-1-r0/packages-split/libpcan/opt/ros/melodic/lib/libpcan.so' [dev-so]
inherit ros_insane_dev_so

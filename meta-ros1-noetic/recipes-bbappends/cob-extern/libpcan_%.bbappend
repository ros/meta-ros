# package.xml declares "LGPL", which is not a valid license identifier.
# Upstream check: package.xml says LGPL; no version found upstream, so the unspecified-version reading applies.
LICENSE = "LGPL-2.0-or-later"

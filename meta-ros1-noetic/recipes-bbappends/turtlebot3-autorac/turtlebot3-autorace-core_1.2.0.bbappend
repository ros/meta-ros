# Copyright (c) 2019 LG Electronics, Inc.

# From http://emanual.robotis.com/docs/en/platform/turtlebot3/autonomous_driving/#tutorials-3-install-additional-dependent-packages:
RDEPENDS_${PN}_append = " \
    image-proc \
    image-transport \
    opencv \
    vision-opencv \
"

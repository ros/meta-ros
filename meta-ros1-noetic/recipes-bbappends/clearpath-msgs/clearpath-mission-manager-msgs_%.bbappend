# package.xml declares "Clearpath-Proprietary", which is not a valid license identifier.
# Upstream check: package.xml: Clearpath Proprietary (repo-level BSD file does not cover this package).
LICENSE = "Proprietary"

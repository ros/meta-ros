# Copyright (c) 2021 LG Electronics, Inc.

DEPENDS += "yaml-cpp"

inherit pkgconfig

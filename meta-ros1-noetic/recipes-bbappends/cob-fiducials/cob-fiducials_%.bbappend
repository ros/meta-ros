# package.xml declares "LGPL", which is not a valid license identifier.
# Upstream check: upstream LICENSE is LGPL v3.
LICENSE = "LGPL-3.0-only"

# Copyright (c) 2021 LG Electronics, Inc.

ROS_EXEC_DEPENDS_remove = "python3-pycryptodome"
ROS_EXEC_DEPENDS_append = " python3-pycryptodomex"

# package.xml declares "LGPL", which is not a valid license identifier.
# Upstream check: upstream COPYING.lib is LGPL v2.1.
LICENSE = "LGPL-2.1-only"

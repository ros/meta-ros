# Copyright (c) 2021 LG Electronics, Inc.

FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://0001-WIP-remove-the-use-of-tbb-task_scheduler_init-it-was.patch"

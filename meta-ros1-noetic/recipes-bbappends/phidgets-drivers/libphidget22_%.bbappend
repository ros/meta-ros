# package.xml declares "LGPL", which is not a valid license identifier.
# Upstream check: upstream LICENSE: libphidget22 is LGPL v3 or later.
LICENSE = "LGPL-3.0-or-later"

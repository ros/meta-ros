# package.xml declares "GPL", which is not a valid license identifier.
# Upstream check: upstream LICENSE: GPL v3 or later.
LICENSE = "GPL-3.0-or-later"

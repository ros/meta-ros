# package.xml declares "BSD-&-GPL", which is not a valid license identifier.
# Upstream check: upstream LICENSE: imu_filter_madgwick GPL v3 or later, rest BSD-3-Clause.
LICENSE = "BSD-3-Clause & GPL-3.0-or-later"

# Copyright (c) 2020 LG Electronics, Inc.

# Doesn't need runtime dependency on ceres-solver
ROS_EXEC_DEPENDS_remove = "ceres-solver"

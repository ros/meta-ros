# Copyright (c) 2020 LG Electronics, Inc.

EXTRA_OECMAKE += "-Dswri_nodelet_SHARE=${RECIPE_SYSROOT}${ros_datadir}/swri_nodelet"

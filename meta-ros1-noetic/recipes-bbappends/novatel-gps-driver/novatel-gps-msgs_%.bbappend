# package.xml declares "Southwest-Research-Institute-Proprietary", which is not a valid license identifier.
# Upstream check: upstream LICENSE is BSD-3-Clause (package.xml names SwRI as a placeholder).
LICENSE = "BSD-3-Clause"

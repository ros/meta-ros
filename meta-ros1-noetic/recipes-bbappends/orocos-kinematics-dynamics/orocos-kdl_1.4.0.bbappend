# Copyright (c) 2019-2020 LG Electronics, Inc.

# Missing license version in package.xml
# https://github.com/orocos/orocos-kdl-release/issues/4
LICENSE = "LGPL-2.1"

# package.xml declares "GPL", which is not a valid license identifier.
# Upstream check: upstream LICENSE is GPL v2.
LICENSE = "GPL-2.0-only"

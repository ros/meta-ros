# Copyright (c) 2021 LG Electronics, Inc.

# It's in ROS_TEST_DEPENDS, but the dependency exists even when testing isn't enabled
DEPENDS += "control-msgs"

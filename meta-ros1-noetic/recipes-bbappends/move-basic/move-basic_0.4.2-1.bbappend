# Copyright (c) 2021 LG Electronics, Inc.

FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://0001-Movebasic.cfg-don-t-try-to-load-move_basic-manifest.patch"

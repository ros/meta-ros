# package.xml declares "GPL", which is not a valid license identifier.
# Upstream check: upstream LICENSE is GPL v3.
LICENSE = "GPL-3.0-only"

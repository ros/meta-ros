# package.xml declares "GPL", which is not a valid license identifier.
# Upstream check: source header says 'GNU LGPL' without a version (package.xml says GPL).
LICENSE = "LGPL-2.0-or-later"

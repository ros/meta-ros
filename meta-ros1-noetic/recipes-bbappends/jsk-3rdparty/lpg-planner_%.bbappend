# package.xml declares "GPL", which is not a valid license identifier.
# Upstream check: package.xml says GPL; no version found upstream.
LICENSE = "GPL-1.0-or-later"

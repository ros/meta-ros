# Copyright (c) 2019-2020 LG Electronics, Inc.

# Missing license version in package.xml
# https://github.com/ANYbotics/rqt_multiplot_plugin/issues/35
LICENSE = "LGPL-3.0"

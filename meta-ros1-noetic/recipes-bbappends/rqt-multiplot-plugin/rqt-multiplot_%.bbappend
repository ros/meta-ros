# package.xml declares "GNU-Lesser-General-Public-License-LGPL-", which is not a valid license identifier.
# Upstream check: source headers are GPL v3 or later (package.xml says LGPL).
LICENSE = "GPL-3.0-or-later"

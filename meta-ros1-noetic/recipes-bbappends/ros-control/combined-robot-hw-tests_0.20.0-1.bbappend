# Copyright (c) 2020 LG Electronics, Inc.

DEPENDS += "controller-manager-tests"

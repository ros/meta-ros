# Copyright (c) 2023 Wind River Systems, Inc.

DEPENDS += "sip3-native python3-pyqt5-native"
LICENSE = "BSD-3-Clause"

# package.xml declares "BSD-&-LGPL-&-LGPL-amcl-", which is not a valid license identifier.
# Upstream check: source headers: amcl is LGPL v2.1 or later, other packages BSD-3-Clause.
LICENSE = "BSD-3-Clause & LGPL-2.1-or-later"

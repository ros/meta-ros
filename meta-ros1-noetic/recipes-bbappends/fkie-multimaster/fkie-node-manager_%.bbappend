# package.xml declares "BSD-&-some-icons-are-licensed-under-LGPL-or-CC-BY-NC-3.0", which is not a valid license identifier.
# Upstream check: upstream LICENSE is BSD-3-Clause; icon sets are Crystal Clear (LGPL, no version) and Deleket (CC-BY-NC-3.0), both shipped.
LICENSE = "BSD-3-Clause & LGPL-2.0-or-later & CC-BY-NC-3.0"

# Copyright (c) 2021 LG Electronics, Inc.

ROS_EXEC_DEPENDS_remove = "avahi"
ROS_EXEC_DEPENDS_append = " avahi-utils"

# Copyright (c) 2021 LG Electronics, Inc.

DEPENDS += "python3-grpcio-tools-native"

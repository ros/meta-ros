# package.xml declares "BSD & Creative-Commons", which is not a valid license identifier.
# Upstream check: upstream LICENSE: BSD-3-Clause code, icons and graphics in the public domain.
LICENSE = "BSD-3-Clause & PD"

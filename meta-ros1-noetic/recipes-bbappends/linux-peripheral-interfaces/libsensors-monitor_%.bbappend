# Copyright (c) 2020 LG Electronics, Inc.

# lmsensors package is empty, so not created, we cannot
# have runtime dependency on it
ROS_EXEC_DEPENDS_remove = "lmsensors"

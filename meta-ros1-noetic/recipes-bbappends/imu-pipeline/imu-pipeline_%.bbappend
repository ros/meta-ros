# package.xml declares "BSD & GPL", which is not a valid license identifier.
# Upstream check: package.xml lists BSD and GPL; no headers or version found upstream.
LICENSE = "BSD-3-Clause & GPL-1.0-or-later"

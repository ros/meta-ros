# package.xml declares "GPL", which is not a valid license identifier.
# Upstream check: package.xml says GPL, a copied header is BSD-3-Clause; no GPL version found upstream.
LICENSE = "BSD-3-Clause & GPL-1.0-or-later"

# Copyright (c) 2020 LG Electronics, Inc.

# it's already included in ROS_TEST_DEPENDS, but
# it's checked in do_configure even when testing isn't enabled
ROS_BUILD_DEPENDS += "roslaunch"

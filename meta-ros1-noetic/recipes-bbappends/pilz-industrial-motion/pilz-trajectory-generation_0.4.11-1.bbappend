# Copyright (c) 2020 LG Electronics, Inc.

DEPENDS += "pilz-industrial-motion-testutils"

# Copyright (c) 2020 LG Electronics, Inc.

# Depends on libntcan with this restriction
COMPATIBLE_MACHINE = "(^$)"
COMPATIBLE_MACHINE_x86-64 = "(.*)"
COMPATIBLE_MACHINE_x86 = "(.*)"

# Copyright (c) 2020 LG Electronics, Inc.

# Rdepends on schunk-powercube-chain, schunk-libm5api, schunk-sdh which depend on libntcan with this restriction
COMPATIBLE_MACHINE = "(^$)"
COMPATIBLE_MACHINE_x86-64 = "(.*)"
COMPATIBLE_MACHINE_x86 = "(.*)"

# Copyright (c) 2019 LG Electronics, Inc.

FILES:${PN}-dev:prepend = "${datadir}/cmake "

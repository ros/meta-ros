# Copyright (c) 2025 Wind River Systems, Inc.

LICENSE = "BSD-3-Clause"

EXTRA_OECMAKE = "-DCMAKE_POLICY_VERSION_MINIMUM=3.5"

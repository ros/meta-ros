# Copyright (c) 2020 LG Electronics, Inc.

# ERROR: QA Issue: non -dev/-dbg/nativesdk- package contains symlink .so: lanelet2-core path '/work/core2-64-oe-linux/lanelet2-core/1.0.1-1-r0/packages-split/lanelet2-core/opt/ros/melodic/lib/liblanelet2_core.so' [dev-so]
inherit ros_insane_dev_so

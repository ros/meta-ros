# package.xml declares "TODO-CATKIN-PACKAGE-LICENSE", which is not a valid license identifier.
# Upstream check: upstream LICENSE is BSD-3-Clause (package.xml has a TODO placeholder).
LICENSE = "BSD-3-Clause"

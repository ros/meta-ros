# Copyright (c) 2020 LG Electronics, Inc.

DEPENDS += "yaml-cpp"
DEPENDS += "gtkmm3"

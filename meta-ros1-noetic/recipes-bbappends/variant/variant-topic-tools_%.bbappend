# package.xml declares "GNU-Lesser-General-Public-License-LGPL-", which is not a valid license identifier.
# Upstream check: upstream repo license is LGPL v3.
LICENSE = "LGPL-3.0-only"

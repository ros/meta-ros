# package.xml declares "BSD & ExiftoolCpp", which is not a valid license identifier.
# Upstream check: upstream: BSD-3-Clause plus bundled ExifTool C++ code that is free for non-commercial use only.
LICENSE = "BSD-3-Clause & Proprietary"

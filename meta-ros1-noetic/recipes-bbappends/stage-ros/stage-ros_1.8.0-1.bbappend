RDEPENDS:${PN} += "bash"

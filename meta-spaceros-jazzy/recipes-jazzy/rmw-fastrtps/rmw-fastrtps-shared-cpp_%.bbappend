# Copyright (c) 2019 LG Electronics, Inc.
# Copyright (c) 2025 Wind River Systems, Inc.

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-ros-native \
    rosidl-adapter-native \
    rosidl-cmake-native \
    rosidl-generator-cpp-native \
    rosidl-generator-py-native \
"

BBCLASSEXTEND = "native nativesdk"


# Copyright (c) 2022 Wind River Systems, Inc.

LICENSE = "BSD-3-Clause"

ROS_BUILDTOOL_DEPENDS = " \
    rosidl-adapter-native \
    rosidl-generator-py-native \
"

# Copyright (c) 2025 Wind River Systems, Inc.

BBCLASSEXTEND = "native nativesdk"

# Copyright (c) 2025 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += "\
    ament-cmake-include-directories\
"

ROS_BUILDTOOL_DEPENDS += "\
    ament-package-native\
    python3-catkin-pkg-native\
"

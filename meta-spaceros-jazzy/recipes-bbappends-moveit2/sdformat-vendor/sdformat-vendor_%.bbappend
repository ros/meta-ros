# Copyright (c) 2025 Wind River Systems, Inc.

ROS_BUILD_DEPENDS:remove = "sdformat14"
ROS_BUILD_DEPENDS:append = " sdformat"

ROS_EXPORT_DEPENDS:remove = "sdformat14"
ROS_EXPORT_DEPENDS:append = " sdformat"

ROS_EXEC_DEPENDS:remove = "sdformat14"
ROS_EXEC_DEPENDS:append = " sdformat"

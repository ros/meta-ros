# Copyright (c) 2025 Wind River Systems, Inc.

# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Boost Software License"
LICENSE = "BSL-1.0"

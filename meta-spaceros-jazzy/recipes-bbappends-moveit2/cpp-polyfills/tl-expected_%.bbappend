# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Creative Commons Zero v1.0 Universal"
LICENSE = "CC0-1.0"

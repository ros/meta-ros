# Copyright (c) 2025 Wind River Systems, Inc.

ROS_BUILDTOOL_DEPENDS += "\
    generate-parameter-library-py-native \
"

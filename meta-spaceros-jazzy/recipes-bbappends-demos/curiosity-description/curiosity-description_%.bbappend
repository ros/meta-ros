# Copyright (c) 2025 Wind River Systems, Inc.

LICENSE = "LicenseRef-GPL"

# Copyright (c) 2025 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += "\
   rclcpp-action\
   control-msgs\
"

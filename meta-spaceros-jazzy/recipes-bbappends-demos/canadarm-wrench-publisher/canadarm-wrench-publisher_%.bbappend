# Copyright (c) 2025 Wind River Systems, Inc.

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://${WORKDIR}/git/ros_trick/LICENSE;md5=175792518e4ac015ab6696d16c4f607e"

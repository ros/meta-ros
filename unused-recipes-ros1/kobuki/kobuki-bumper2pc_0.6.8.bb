DESCRIPTION = "Bumper/cliff to pointcloud nodelet"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "roscpp nodelet pluginlib kobuki-msgs sensor-msgs"

require kobuki.inc

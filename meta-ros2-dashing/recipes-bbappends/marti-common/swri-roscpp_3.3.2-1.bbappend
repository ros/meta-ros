# Copyright (c) 2019 LG Electronics, Inc.

FILES:${PN} += "${prefix}/launch"

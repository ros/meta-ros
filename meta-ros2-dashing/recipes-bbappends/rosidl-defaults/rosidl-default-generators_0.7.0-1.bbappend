# Copyright (c) 2019 LG Electronics, Inc.

# XXX This was a guess that caused a bunch of recipes to build -- should check the source!!
ROS_BUILDTOOL_EXPORT_DEPENDS += " \
    rosidl-parser-native \
"

# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILD_DEPENDS += " \
    ament-cmake-core \
    python-cmake-module \
"

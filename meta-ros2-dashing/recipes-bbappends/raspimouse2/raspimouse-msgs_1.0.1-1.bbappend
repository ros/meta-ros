# Copyright (c) 2020 LG Electronics, Inc.

ROS_BUILD_DEPENDS += " \
    fastcdr \
    fastrtps \
    rosidl-generator-c \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    rcutils \
    rmw \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
"

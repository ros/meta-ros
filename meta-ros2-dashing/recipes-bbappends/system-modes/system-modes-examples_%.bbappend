# Copyright (c) 2019 LG Electronics, Inc.

FILES:${PN}:prepend = "${datadir}/example_modes.yaml "

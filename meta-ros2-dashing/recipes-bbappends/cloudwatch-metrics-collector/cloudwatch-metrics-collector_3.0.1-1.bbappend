# Copyright (c) 2019 LG Electronics, Inc.

# cloudwatch-metrics-common is just headers/staticlib files and PN is empty, so it wasn't created
ROS_EXEC_DEPENDS_remove = "cloudwatch-metrics-common"

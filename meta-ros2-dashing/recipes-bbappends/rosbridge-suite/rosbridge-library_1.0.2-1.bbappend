# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    rosidl-adapter-native \
    python-cmake-module-native \
    python3-numpy-native \
    rosidl-default-generators-native \
"

# Copyright (c) YEAR LG Electronics, Inc.

ROS_BUILD_DEPENDS_remove = "rosidl-typesupport-connext-cpp"
ROS_BUILD_DEPENDS_remove = "rosidl-typesupport-opensplice-cpp"

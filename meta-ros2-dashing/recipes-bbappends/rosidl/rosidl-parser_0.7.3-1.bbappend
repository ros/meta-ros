# Copyright (c) 2019 LG Electronics, Inc.

ROS_EXPORT_DEPENDS += " \
    python3-lark-parser \
"

# Copyright (c) 2020 LG Electronics, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    rclcpp-components \
    eigen3-cmake-module \
"

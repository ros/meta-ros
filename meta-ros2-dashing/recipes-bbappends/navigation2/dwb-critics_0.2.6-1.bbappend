# Copyright (c) 2019 LG Electronics, Inc.

FILES:${PN} += "${datadir}/default_critics.xml"

# Copyright (c) 2019 LG Electronics, Inc.

DEPENDS += "eigen3-cmake-module"

FILES_${PN} += "${datadir}/costmap_plugins.xml"

# Copyright (c) 2020 LG Electronics, Inc.

DEPENDS += "ament-cmake-ros-native \
    boost \
    rcutils \
    rcl \
    rosidl-generator-c \
    rosidl-adapter \
"

# Copyright (c) 2021 LG Electronics, Inc.

# dashing, eloquent branches were deleted for some reason, reported at https://github.com/ros2-gbp/osrf_testings_tools_cpp-release/issues/2
ROS_BRANCH = "nobranch=1"

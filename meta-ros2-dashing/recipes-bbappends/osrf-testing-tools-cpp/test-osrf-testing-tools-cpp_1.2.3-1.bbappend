# Copyright (c) 2019-2021 LG Electronics, Inc.

ROS_BUILD_DEPENDS += "osrf-testing-tools-cpp"

# dashing, eloquent branches were deleted for some reason, reported at https://github.com/ros2-gbp/osrf_testings_tools_cpp-release/issues/2
ROS_BRANCH = "nobranch=1"

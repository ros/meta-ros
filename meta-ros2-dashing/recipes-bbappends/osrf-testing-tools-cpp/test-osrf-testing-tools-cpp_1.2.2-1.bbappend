# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILD_DEPENDS += "osrf-testing-tools-cpp"

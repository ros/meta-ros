# Copyright (c) 2020 LG Electronics, Inc.

ROS_BUILD_DEPENDS += " \
    rosidl-adapter-native \
    python-cmake-module \
    python3-numpy-native \
    rosidl-generator-cpp-native \
    rosidl-typesupport-introspection-cpp-native \
    rosidl-typesupport-fastrtps-cpp-native \
    rosidl-typesupport-cpp-native \
    rosidl-typesupport-fastrtps-c-native \
    rosidl-generator-py-native \
"

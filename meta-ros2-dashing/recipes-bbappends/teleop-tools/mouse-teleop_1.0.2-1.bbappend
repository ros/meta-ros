# Copyright (c) 2019 LG Electronics, Inc.

ROS_EXEC_DEPENDS_remove = "python-numpy"
ROS_EXEC_DEPENDS_append = " python3-numpy"

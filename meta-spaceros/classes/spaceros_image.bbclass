# Copyright (c) 2019 LG Electronics, Inc.
# Copyright (c) 2025 Wind River Systems, Inc.

inherit ros_image
inherit ros2_image

# Place metadata unique to Space ROS images here.

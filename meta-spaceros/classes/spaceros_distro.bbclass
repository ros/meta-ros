# Copyright (c) 2019-2020 LG Electronics, Inc.
# Copyright (c) 2025 Wind River Systems, Inc.

# inherit ros_distro

# Set to match SPACEROS_DIR in space-ros/space-ros/Earthfile
ros_base_prefix = "/opt/ros/spaceros"

inherit ros_opt_prefix

inherit ros2_distro

# Place metadata unique to Space ROS distros here.

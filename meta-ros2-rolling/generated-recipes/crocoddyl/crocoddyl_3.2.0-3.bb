# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_rolling
inherit ros_superflore_generated

DESCRIPTION = "Crocoddyl optimal control library"
AUTHOR = "Carlos Mastalli <carlos.mastalli@gmail.com>"
HOMEPAGE = "https://github.com/loco-3d/crocoddyl"
SECTION = "devel"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=4633480cdd27d7906aaf3ef4b72014b2"

ROS_CN = "crocoddyl"
ROS_BPN = "crocoddyl"

ROS_BUILD_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-coinor-libipopt-dev} \
    boost \
    doxygen \
    eigenpy \
    git \
    jrl-cmakemodules \
    pinocchio \
    python3 \
    python3-numpy \
"

ROS_BUILDTOOL_DEPENDS = " \
    cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-coinor-libipopt-dev} \
    boost \
    eigenpy \
    pinocchio \
    python3 \
    python3-numpy \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-coinor-libipopt-dev} \
    ament-cmake \
    boost \
    eigenpy \
    pinocchio \
    python3 \
    python3-numpy \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/crocoddyl-release/archive/release/rolling/crocoddyl/3.2.0-3.tar.gz
ROS_BRANCH ?= "branch=release/rolling/crocoddyl"
SRC_URI = "git://github.com/ros2-gbp/crocoddyl-release;${ROS_BRANCH};protocol=https"
SRCREV = "2801a2cc54bfe6dcaca1e44a6b0f0c18a707745e"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_rolling
inherit ros_superflore_generated

DESCRIPTION = "Default plugins for the QML-based robotics visualization and control tool RQml for ROS 2."
AUTHOR = "Stefan Fabian <fabian@sim.tu-darmstadt.de>"
ROS_AUTHOR = "Stefan Fabian <fabian@sim.tu-darmstadt.de>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "GPL-3.0-only"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=9c2b4f259ad099b703e1cfabd83d05c2"

ROS_CN = "rqml"
ROS_BPN = "rqml_default_plugins"

ROS_BUILD_DEPENDS = " \
    rqml-core \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    rqml-core \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-qml6-module-qt-labs-qmlmodels} \
    ${ROS_UNRESOLVED_DEP-qml6-module-qtmultimedia} \
    ${ROS_UNRESOLVED_DEP-qml6-module-qtquick-controls} \
    ${ROS_UNRESOLVED_DEP-qml6-module-qtquick-dialogs} \
    ${ROS_UNRESOLVED_DEP-qml6-module-qtquick-layouts} \
    control-msgs \
    controller-manager-msgs \
    geometry-msgs \
    moveit-msgs \
    pal-statistics-msgs \
    qml6-ros2-plugin \
    rqml-core \
    sensor-msgs \
    tf2-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-lint-auto \
    qml6-ros2-plugin \
    rcl-interfaces \
    ros-babel-fish-test-msgs \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/rqml-release/archive/release/rolling/rqml_default_plugins/3.26.42-1.tar.gz
ROS_BRANCH ?= "branch=release/rolling/rqml_default_plugins"
SRC_URI = "git://github.com/ros2-gbp/rqml-release;${ROS_BRANCH};protocol=https"
SRCREV = "e82470a5533fdfd4afcb5a306e83145553aef4d8"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_rolling
inherit ros_superflore_generated

DESCRIPTION = "ROS2 Snapshot - contains workspace modeler and snapshot tools"
AUTHOR = "CNU Robotics CHRISLab <robotics@cnu.edu>"
ROS_AUTHOR = "Andrew Farney <andrew.farney.22@cnu.edu>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "ros2_snapshot"
ROS_BPN = "ros2_snapshot"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = ""

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-python3-graphviz} \
    ament-index-python \
    graphviz \
    python3-psutil \
    python3-pydantic \
    python3-pyyaml \
    rclpy \
    ros2cli \
    ros2component \
    ros2node \
    ros2param \
    ros2pkg \
    ros2service \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    demo-nodes-py \
    python3-pytest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/ros2_snapshot-release/archive/release/rolling/ros2_snapshot/0.0.6-2.tar.gz
ROS_BRANCH ?= "branch=release/rolling/ros2_snapshot"
SRC_URI = "git://github.com/ros2-gbp/ros2_snapshot-release;${ROS_BRANCH};protocol=https"
SRCREV = "1f447ad6b17ca6ff7ee8f639b218d3e9042bc705"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_python"

inherit ros_${ROS_BUILD_TYPE}

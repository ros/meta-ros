# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_rolling
inherit ros_superflore_generated

DESCRIPTION = "Nav2 Minimum TurtleBot4 Simulation"
AUTHOR = "Steve Macenski <steve@opennav.org>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=3dce4ba60d7e51ec64f3c3dc18672dd3"

ROS_CN = "nav2_minimal_turtlebot_simulation"
ROS_BPN = "nav2_minimal_tb4_sim"

ROS_BUILD_DEPENDS = " \
    nav2-minimal-tb4-description \
    robot-state-publisher \
    ros-gz-bridge \
    ros-gz-image \
    ros-gz-interfaces \
    ros-gz-sim \
    xacro \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    nav2-minimal-tb4-description \
    robot-state-publisher \
    ros-gz-bridge \
    ros-gz-image \
    ros-gz-interfaces \
    ros-gz-sim \
    xacro \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    nav2-minimal-tb4-description \
    robot-state-publisher \
    ros-gz-bridge \
    ros-gz-image \
    ros-gz-interfaces \
    ros-gz-sim \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros-navigation/nav2_minimal_turtlebot_simulation-release/archive/release/rolling/nav2_minimal_tb4_sim/1.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/rolling/nav2_minimal_tb4_sim"
SRC_URI = "git://github.com/ros-navigation/nav2_minimal_turtlebot_simulation-release;${ROS_BRANCH};protocol=https"
SRCREV = "36fc39980e4c61e5fcc0cdf9d571c5c9b026ae84"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

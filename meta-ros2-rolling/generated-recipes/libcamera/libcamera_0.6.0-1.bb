# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_rolling
inherit ros_superflore_generated

DESCRIPTION = "An open source camera stack and framework for Linux, Android, and ChromeOS"
AUTHOR = "Christian Rauch <Rauch.Christian@gmx.de>"
ROS_AUTHOR = "libcamera project <libcamera-devel@lists.libcamera.org>"
HOMEPAGE = "https://libcamera.org"
SECTION = "devel"
LICENSE = "Apache-2.0 & BSD-2-Clause & BSD-3-Clause & GPL-2.0-or-later & LGPL-2.1-or-later"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "libcamera"
ROS_BPN = "libcamera"

ROS_BUILD_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-libyuv-dev} \
    gcc-runtime \
    libyaml \
    openssl \
    python3 \
    python3-jinja2 \
    python3-ply \
    python3-pybind11 \
    python3-pyyaml \
    udev \
"

ROS_BUILDTOOL_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-meson-native} \
    git-native \
    pkgconfig-native \
"

ROS_EXPORT_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-libyuv-dev} \
    gcc-runtime \
    libyaml \
    openssl \
    python3 \
    udev \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-libyuv-dev} \
    gcc-runtime \
    libyaml \
    openssl \
    python3 \
    udev \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/libcamera-release/archive/release/rolling/libcamera/0.6.0-1.tar.gz
ROS_BRANCH ?= "branch=release/rolling/libcamera"
SRC_URI = "git://github.com/ros2-gbp/libcamera-release;${ROS_BRANCH};protocol=https"
SRCREV = "cc2e47cce5feec37e13a79164c033f1e3fc09596"

ROS_BUILD_TYPE = "meson"

inherit ros_${ROS_BUILD_TYPE}

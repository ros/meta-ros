# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_rolling
inherit ros_superflore_generated

DESCRIPTION = "A package of commonly image manipulation utilities."
AUTHOR = "Southwest Research Institute <swri-robotics@swri.org>"
ROS_AUTHOR = "Kris Kozak"
HOMEPAGE = "https://github.com/swri-robotics/marti_common"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "marti_common"
ROS_BPN = "swri_image_util"

ROS_BUILD_DEPENDS = " \
    ament-index-cpp \
    camera-calibration-parsers \
    cv-bridge \
    image-geometry \
    image-transport \
    libeigen \
    message-filters \
    opencv \
    rcl-interfaces \
    rclcpp \
    rclcpp-components \
    rclpy \
    swri-geometry-util \
    swri-math-util \
    swri-opencv-util \
    tf2 \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
    pkgconfig-native \
"

ROS_EXPORT_DEPENDS = " \
    ament-index-cpp \
    camera-calibration-parsers \
    cv-bridge \
    image-geometry \
    image-transport \
    libeigen \
    message-filters \
    opencv \
    rcl-interfaces \
    rclcpp \
    rclcpp-components \
    rclpy \
    swri-geometry-util \
    swri-math-util \
    swri-opencv-util \
    tf2 \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ament-index-cpp \
    camera-calibration-parsers \
    cv-bridge \
    image-geometry \
    image-transport \
    libeigen \
    message-filters \
    opencv \
    rcl-interfaces \
    rclcpp \
    rclcpp-components \
    rclpy \
    swri-geometry-util \
    swri-math-util \
    swri-opencv-util \
    tf2 \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-gtest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/marti_common-release/archive/release/rolling/swri_image_util/3.8.5-1.tar.gz
ROS_BRANCH ?= "branch=release/rolling/swri_image_util"
SRC_URI = "git://github.com/ros2-gbp/marti_common-release;${ROS_BRANCH};protocol=https"
SRCREV = "869379b5d2ca65340d7a5898b5b59311ccf1b047"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_rolling
inherit ros_superflore_generated

DESCRIPTION = "ROS package for interfacing with LLM's and VLM's using OpenAI compatible API."
AUTHOR = "Bob Ros <bobmeuchelm@gmail.com>"
ROS_AUTHOR = "Bob Ros <bobmeuchelm@gmail.com>"
HOMEPAGE = "https://github.com/bob-ros2/bob_llm"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "bob_llm"
ROS_BPN = "bob_llm"

ROS_BUILD_DEPENDS = " \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    python3-pyyaml \
    python3-requests \
    rclpy \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/bob-ros2/bob_llm-release/archive/release/rolling/bob_llm/1.0.2-1.tar.gz
ROS_BRANCH ?= "branch=release/rolling/bob_llm"
SRC_URI = "git://github.com/bob-ros2/bob_llm-release;${ROS_BRANCH};protocol=https"
SRCREV = "ce236aa032182df1a598222e342d63c788ac8f4f"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

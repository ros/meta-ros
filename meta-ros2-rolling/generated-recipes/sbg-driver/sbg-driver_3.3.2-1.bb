# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_rolling
inherit ros_superflore_generated

DESCRIPTION = "ROS driver package for communication with the SBG navigation systems."
AUTHOR = "SBG Systems <support@sbg-systems.com>"
ROS_AUTHOR = "SBG Systems"
HOMEPAGE = "http://wiki.ros.org/sbg_driver"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "sbg_driver"
ROS_BPN = "sbg_driver"

ROS_BUILD_DEPENDS = " \
    geometry-msgs \
    nav-msgs \
    nmea-msgs \
    rclcpp \
    rtcm-msgs \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf2-geometry-msgs \
    tf2-msgs \
    tf2-ros \
    urdf \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
    rosidl-default-generators-native \
"

ROS_EXPORT_DEPENDS = " \
    geometry-msgs \
    nav-msgs \
    nmea-msgs \
    rclcpp \
    rtcm-msgs \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf2-geometry-msgs \
    tf2-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    geometry-msgs \
    nav-msgs \
    nmea-msgs \
    rclcpp \
    rosidl-default-runtime \
    rtcm-msgs \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf2-geometry-msgs \
    tf2-msgs \
    tf2-ros \
    urdf \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/SBG-Systems/sbg_ros2-release/archive/release/rolling/sbg_driver/3.3.2-1.tar.gz
ROS_BRANCH ?= "branch=release/rolling/sbg_driver"
SRC_URI = "git://github.com/SBG-Systems/sbg_ros2-release;${ROS_BRANCH};protocol=https"
SRCREV = "596d5ddd14b476e2a938de058b9f66edf712afc5"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

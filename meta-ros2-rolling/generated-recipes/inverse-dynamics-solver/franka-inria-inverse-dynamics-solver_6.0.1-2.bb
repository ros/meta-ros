# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_rolling
inherit ros_superflore_generated

DESCRIPTION = "A C++ library implementing the inverse dynamics solver for the Franka Emika Panda (FER) real robot."
AUTHOR = "Enrico Ferrentino <eferrentino@unisa.it>"
ROS_AUTHOR = "Vincenzo Petrone <vipetrone@unisa.it>"
HOMEPAGE = "https://github.com/unisa-acg/inverse-dynamics-solver.git"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "inverse_dynamics_solver"
ROS_BPN = "franka_inria_inverse_dynamics_solver"

ROS_BUILD_DEPENDS = " \
    inverse-dynamics-solver \
    libeigen \
    pluginlib \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    inverse-dynamics-solver \
    libeigen \
    pluginlib \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    inverse-dynamics-solver \
    libeigen \
    pluginlib \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/inverse_dynamics_solver-release/archive/release/rolling/franka_inria_inverse_dynamics_solver/6.0.1-2.tar.gz
ROS_BRANCH ?= "branch=release/rolling/franka_inria_inverse_dynamics_solver"
SRC_URI = "git://github.com/ros2-gbp/inverse_dynamics_solver-release;${ROS_BRANCH};protocol=https"
SRCREV = "d6388bedd7404b57bf4baecc68f373433c69d6bd"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

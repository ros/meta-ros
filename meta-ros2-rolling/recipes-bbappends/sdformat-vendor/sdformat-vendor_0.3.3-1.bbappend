# Copyright (c) 2024 Wind River Systems, Inc.

DEPENDS += "sdformat"

inherit ros_insane_dev_so

# Copyright (c) 2024 Wind River Systems, Inc.

DEPENDS += "sdformat"

export GZ_RELAX_VERSION_MATCH="1"

inherit ros_insane_dev_so

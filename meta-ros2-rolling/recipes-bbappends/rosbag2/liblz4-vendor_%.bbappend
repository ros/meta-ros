LICENSE = "Apache-2.0 & BSD-2-Clause & GPL-2.0-only"

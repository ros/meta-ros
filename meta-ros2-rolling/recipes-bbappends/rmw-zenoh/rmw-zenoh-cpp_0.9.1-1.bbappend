LICENSE = "Apache-2.0 & BSD-3-Clause"

ROS_BUILD_DEPENDS += "\
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
"

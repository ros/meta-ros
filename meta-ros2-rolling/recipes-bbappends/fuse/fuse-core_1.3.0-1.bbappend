# Copyright (c) 2021 LG Electronics, Inc.

# Doesn't need runtime dependency on ceres-solver
ROS_EXEC_DEPENDS:remove = "ceres-solver"

inherit pkgconfig

# Copyright (c) 2025 Wind River Systems, Inc.

LICENSE = "BSD-3-Clause"

ROS_BUILD_DEPENDS:append = " \
    ament-cmake-ros-core-native \
"

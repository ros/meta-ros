# Copyright (c) 2020-2021 LG Electronics, Inc.

DEPENDS += "jsoncpp"

inherit pkgconfig

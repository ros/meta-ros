# Copyright (c) 2024 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += " \
    point-cloud-transport-plugins \
"

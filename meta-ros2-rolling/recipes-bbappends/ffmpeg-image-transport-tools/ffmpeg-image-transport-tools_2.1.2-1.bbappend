inherit pkgconfig


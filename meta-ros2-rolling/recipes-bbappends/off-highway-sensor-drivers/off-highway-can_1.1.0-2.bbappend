# Copyright (c) 2025 Wind River Systems, Inc.

LICENSE = "Apache-2.0 && MIT"

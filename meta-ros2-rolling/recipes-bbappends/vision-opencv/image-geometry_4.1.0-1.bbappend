# Copyright (c) 2022-2023 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += " \
    service-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-ros-native \
    python3-numpy-native \
"

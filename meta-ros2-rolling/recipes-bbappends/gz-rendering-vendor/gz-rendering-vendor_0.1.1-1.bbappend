# Copyright (c) 2024 Wind River Systems, Inc.

export GZ_RELAX_VERSION_MATCH="1"

ROS_BUILD_DEPENDS += "gz-rendering8"

ROS_BUILDTOOL_DEPENDS += "cppcheck-native doxygen-native"

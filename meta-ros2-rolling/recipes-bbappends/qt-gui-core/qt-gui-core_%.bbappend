# Copyright (c) 2023-2026 Wind River Systems, Inc.

LICENSE = "BSD-3-Clause"

include qt6-support.inc
S = "${UNPACKDIR}/${BB_GIT_DEFAULT_DESTSUFFIX}/qt_gui_core"

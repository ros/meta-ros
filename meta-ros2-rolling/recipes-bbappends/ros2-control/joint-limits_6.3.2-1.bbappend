FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Remove-missing-braces-and-shadow-warning-as-errors.patch"


# Copyright (c) 2019-2020 LG Electronics, Inc.

DEPENDS += "eigen3-cmake-module"

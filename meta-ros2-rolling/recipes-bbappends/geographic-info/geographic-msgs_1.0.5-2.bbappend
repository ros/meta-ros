# Copyright (c) 2023 Wind River Systems, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    rosidl-default-generators-native \
"

ROS_BUILD_DEPENDS += " \
    service-msgs \
"

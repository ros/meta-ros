FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Include-the-CPM.cmake-only-when-needed.patch"

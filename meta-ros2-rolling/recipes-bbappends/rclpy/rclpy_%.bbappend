DEPENDS:append = " \
    python3-numpy \
    python3-numpy-native \
"

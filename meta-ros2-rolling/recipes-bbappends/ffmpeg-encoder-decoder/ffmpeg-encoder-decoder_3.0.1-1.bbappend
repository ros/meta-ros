CXXFLAGS += "-Wno-error=deprecated-declarations"

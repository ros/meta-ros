DEPENDS:append = " \
    python3-numpy-native \
"

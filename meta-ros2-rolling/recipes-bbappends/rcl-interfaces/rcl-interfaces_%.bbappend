# Otherwise, we get a QA [file-rdeps] on libraries from service-msgs

DEPENDS:append = " \
    service-msgs \
"

# Copyright (c) 2023 Wind River Systems, Inc.

# Could not find a package configuration file provided by "rosidl_core_runtime"
ROS_BUILD_DEPENDS += " \
    rosidl-core-runtime \
"

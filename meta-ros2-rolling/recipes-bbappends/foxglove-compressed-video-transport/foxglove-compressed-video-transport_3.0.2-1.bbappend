inherit pkgconfig

CXXFLAGS += "-Wno-error=deprecated-declarations"

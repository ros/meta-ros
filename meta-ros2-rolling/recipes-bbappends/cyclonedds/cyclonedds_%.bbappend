# LICENSE is set to Eclipse-Distribution-License-1.0 in the generated
# bb
LICENSE = "EDL-1.0"

FILES:${PN}-dev += " \
    ${libdir}/libddsc.so \
    ${libdir}/libddsc.so.0 \
"

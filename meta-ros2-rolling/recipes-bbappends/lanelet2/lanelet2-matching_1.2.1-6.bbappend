# Copyright (c) 2023 Wind River Systems, Inc.

# QA Issue: non -dev/-dbg/nativesdk- package moveit-ros-visualization contains symlink .so
FILES:${PN}-dev += "${libdir}/liblanelet2_matching.so"

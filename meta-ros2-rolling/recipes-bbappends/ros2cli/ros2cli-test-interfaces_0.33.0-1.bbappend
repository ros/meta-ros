# Copyright (c) 2021 LG Electronics, Inc.

DEPENDS += "\
    rosidl-typesupport-fastrtps-c-native \
    rosidl-typesupport-fastrtps-cpp-native \
"

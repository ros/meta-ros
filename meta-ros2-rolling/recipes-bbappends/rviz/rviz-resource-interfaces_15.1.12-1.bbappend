# Copyright (c) 2025 Wind River Systems, Inc.

# ld: .../rviz-resource-interfaces/15.0.0-1-r0/recipe-sysroot-native/opt/ros/kilted/lib/libservice_msgs__rosidl_generator_c.so: error adding symbols: file in wrong format
ROS_BUILD_DEPENDS += "service-msgs"

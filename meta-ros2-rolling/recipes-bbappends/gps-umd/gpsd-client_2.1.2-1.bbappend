# Copyright (c) 2021 LG Electronics, Inc.
# Copyright (c) 2025 Wind River Systems, Inc.

LICENSE = "BSD-3-Clause"

inherit pkgconfig

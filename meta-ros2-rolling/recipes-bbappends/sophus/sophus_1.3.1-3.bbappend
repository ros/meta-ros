EXTRA_OECMAKE:append = " \
    -DBUILD_SOPHUS_EXAMPLES=OFF \
    -DBUILD_SOPHUS_TESTS=OFF \
"

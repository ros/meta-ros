# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILD_DEPENDS += " \
    rosidl-cmake \
    rosidl-default-runtime \
"

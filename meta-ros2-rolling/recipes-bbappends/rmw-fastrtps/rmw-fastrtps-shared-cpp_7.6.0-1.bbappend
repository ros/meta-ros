# Copyright (c) 2019 LG Electronics, Inc.
# Copyright (c) 2022 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += " \
    rosidl-cmake \
    rosidl-default-runtime \
    rosidl-generator-cpp \
"

ROS_BUILDTOOL_DEPENDS = " \
    rosidl-generator-py-native \
"

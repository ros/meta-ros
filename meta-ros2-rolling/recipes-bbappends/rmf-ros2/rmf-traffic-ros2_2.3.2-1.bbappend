# Copyright (c) 2022 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += "eigen3-cmake-module"

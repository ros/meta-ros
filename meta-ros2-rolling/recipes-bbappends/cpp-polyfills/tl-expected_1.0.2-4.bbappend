# Fixing BSD license not using correct SPDX Syntax
LICENSE = "CC0-1.0"

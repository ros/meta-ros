FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://0001-fixing-python-shabang-to-Python-of-target.patch"

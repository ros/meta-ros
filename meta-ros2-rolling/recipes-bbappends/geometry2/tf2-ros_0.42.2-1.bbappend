# Copyright (c) 2022 Wind River Systems, Inc.

ROS_BUILDTOOL_DEPENDS = " \
    rosidl-adapter-native \
    rosidl-generator-py-native \
"

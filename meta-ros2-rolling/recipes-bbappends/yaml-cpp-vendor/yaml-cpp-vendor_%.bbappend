# Copyright (c) 2019-2020 LG Electronics, Inc.

DESCRIPTION = "Wrapper around yaml-cpp, it provides a fixed CMake module."

require ../../generated-recipes/fuse/fuse-doc_${PV}.bb

LICENSE = "BSD-3-Clause"

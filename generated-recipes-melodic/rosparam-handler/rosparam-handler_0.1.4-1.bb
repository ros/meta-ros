# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "An easy wrapper for using parameters in ROS."
AUTHOR = "Jeremie Deray <jeremie.deray@pal-robotics.com>"
ROS_AUTHOR = "Claudio Bandera <cbandera@posteo.de>"
HOMEPAGE = "https://github.com/cbandera/rosparam_handler.git"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=6;endline=6;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "rosparam_handler"
ROS_BPN = "rosparam_handler"

ROS_BUILD_DEPENDS = " \
    rostest \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    catkin \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    catkin \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    dynamic-reconfigure \
    roscpp \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/cbandera/rosparam_handler-release/archive/release/melodic/rosparam_handler/0.1.4-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "9f62b3f282bffdcd988c4c744a1ac3bc"
SRC_URI[sha256sum] = "b11ba2d257e5c7fc2c50f3e9eea117867178ed67a74906e21ebfad9f222f3fba"
S = "${WORKDIR}/rosparam_handler-release-release-melodic-rosparam_handler-0.1.4-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('rosparam-handler', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('rosparam-handler', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rosparam-handler/rosparam-handler_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rosparam-handler/rosparam-handler-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rosparam-handler/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rosparam-handler/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

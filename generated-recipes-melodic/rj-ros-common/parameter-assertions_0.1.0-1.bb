# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "A library for ROS parameter assertions"
AUTHOR = "Oswin So <oswinso@gmail.com>"
ROS_AUTHOR = "Oswin So <oswinso@gmail.com>"
HOMEPAGE = "http://www.robojackets.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "rj-ros-common"
ROS_BPN = "parameter_assertions"

ROS_BUILD_DEPENDS = " \
    roscpp \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    roscpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    roscpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    rostest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/RoboJackets/rj-ros-common-release/archive/release/melodic/parameter_assertions/0.1.0-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "5ec68de31e2e9e91af7ea5e5e68cb973"
SRC_URI[sha256sum] = "639173429975b82767392b4c719fff84c22fc31c40aa83b04bcda8b8eeca6df8"
S = "${WORKDIR}/rj-ros-common-release-release-melodic-parameter_assertions-0.1.0-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('rj-ros-common', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('rj-ros-common', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rj-ros-common/rj-ros-common_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rj-ros-common/rj-ros-common-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rj-ros-common/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rj-ros-common/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

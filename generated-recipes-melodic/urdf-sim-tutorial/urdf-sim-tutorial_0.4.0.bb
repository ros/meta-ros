# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The urdf_sim_tutorial package"
AUTHOR = "David V. Lu!! <davidvlu@gmail.com>"
ROS_AUTHOR = "David V. Lu!! <davidvlu@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "urdf_sim_tutorial"
ROS_BPN = "urdf_sim_tutorial"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    controller-manager \
    diff-drive-controller \
    gazebo-ros \
    gazebo-ros-control \
    joint-state-controller \
    position-controllers \
    robot-state-publisher \
    rqt-robot-steering \
    rviz \
    urdf-tutorial \
    xacro \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    controller-manager \
    diff-drive-controller \
    gazebo-ros \
    gazebo-ros-control \
    joint-state-controller \
    position-controllers \
    robot-state-publisher \
    rqt-robot-steering \
    rviz \
    urdf-tutorial \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ros-gbp/urdf_sim_tutorial-release/archive/release/melodic/urdf_sim_tutorial/0.4.0-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "0949eeb205339e9e074ce927511da244"
SRC_URI[sha256sum] = "520f94f7fe52250069283fc7bdd40b734e9153bdcc11b76309fe9522972d8f77"
S = "${WORKDIR}/urdf_sim_tutorial-release-release-melodic-urdf_sim_tutorial-0.4.0-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('urdf-sim-tutorial', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('urdf-sim-tutorial', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/urdf-sim-tutorial/urdf-sim-tutorial_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/urdf-sim-tutorial/urdf-sim-tutorial-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/urdf-sim-tutorial/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/urdf-sim-tutorial/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

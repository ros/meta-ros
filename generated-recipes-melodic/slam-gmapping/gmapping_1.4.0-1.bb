# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "This package contains a ROS wrapper for OpenSlam's Gmapping.    The gmapping package provides laser-based SLAM (Simultaneous Localization and Mapping),    as a ROS node called slam_gmapping. Using slam_gmapping, you can create a 2-D occupancy   grid map (like a building floorplan) from laser and pose data collected by a mobile robot."
AUTHOR = "ROS Orphaned Package Maintainers <ros-orphaned-packages@googlegroups.com>"
ROS_AUTHOR = "Brian Gerkey"
HOMEPAGE = "http://ros.org/wiki/gmapping"
SECTION = "devel"
LICENSE = "BSD & Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "slam_gmapping"
ROS_BPN = "gmapping"

ROS_BUILD_DEPENDS = " \
    nav-msgs \
    nodelet \
    openslam-gmapping \
    roscpp \
    rostest \
    tf \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    nav-msgs \
    nodelet \
    openslam-gmapping \
    roscpp \
    tf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    nav-msgs \
    nodelet \
    openslam-gmapping \
    roscpp \
    tf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ros-gbp/slam_gmapping-release/archive/release/melodic/gmapping/1.4.0-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "38e282fbdc191b3f4ef92545fe23b337"
SRC_URI[sha256sum] = "0cb572f0b00c39ecc0989a195f137172cf6a3481a176bb829484d6d731a00ea1"
S = "${WORKDIR}/slam_gmapping-release-release-melodic-gmapping-1.4.0-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('slam-gmapping', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('slam-gmapping', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/slam-gmapping/slam-gmapping_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/slam-gmapping/slam-gmapping-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/slam-gmapping/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/slam-gmapping/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

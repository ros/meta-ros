# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The Pepperl+Fuchs R2000 laser range finder driver package"
AUTHOR = "Denis Dillenberger <denis.dillenberger@gmail.com>"
ROS_AUTHOR = "Denis Dillenberger <denis.dillenberger@gmail.com>"
HOMEPAGE = "http://wiki.ros.org/pepperl_fuchs_r2000"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "pepperl_fuchs"
ROS_BPN = "pepperl_fuchs_r2000"

ROS_BUILD_DEPENDS = " \
    roscpp \
    sensor-msgs \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    roscpp \
    sensor-msgs \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    roscpp \
    sensor-msgs \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/dillenberger/pepperl_fuchs-release/archive/release/melodic/pepperl_fuchs_r2000/0.1.3-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "9b170f6a4bc8617663557590598a1d53"
SRC_URI[sha256sum] = "833c1e411a45ec3640a3b9711241ef46c5ba36ceaa0ee0496d183f4fbb246c1f"
S = "${WORKDIR}/pepperl_fuchs-release-release-melodic-pepperl_fuchs_r2000-0.1.3-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('pepperl-fuchs', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('pepperl-fuchs', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pepperl-fuchs/pepperl-fuchs_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pepperl-fuchs/pepperl-fuchs-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pepperl-fuchs/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pepperl-fuchs/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

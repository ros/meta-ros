# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "This is SDHLibrary-CPP, the C++ library to access   an SDH (SCHUNK Dexterous Hand)"
AUTHOR = "Christian Rauch <Christian.Rauch@ed.ac.uk>"
ROS_AUTHOR = "Dirk Osswald <dirk.osswald@de.schunk.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=3dce4ba60d7e51ec64f3c3dc18672dd3"

ROS_CN = "sdhlibrary_cpp"
ROS_BPN = "sdhlibrary_cpp"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = ""

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ipab-slmc/SDHLibrary-CPP-release/archive/release/melodic/sdhlibrary_cpp/0.2.10-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "4e108e5665f79706b552cc8fd34c6922"
SRC_URI[sha256sum] = "cdc88eafafbe1def8674349fac30f504bd9d354416ec2a2daa58e47d3d138db3"
S = "${WORKDIR}/SDHLibrary-CPP-release-release-melodic-sdhlibrary_cpp-0.2.10-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('sdhlibrary-cpp', d)}"
ROS_BUILD_TYPE = "cmake"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('sdhlibrary-cpp', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/sdhlibrary-cpp/sdhlibrary-cpp_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/sdhlibrary-cpp/sdhlibrary-cpp-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/sdhlibrary-cpp/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/sdhlibrary-cpp/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

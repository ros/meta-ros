# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The um7 package provides a C++ implementation of the CH Robotics serial protocol, and a     corresponding ROS node for publishing standard ROS orientation topics from a UM7."
AUTHOR = "Daniel Miller <dgmiller@ncsu.edu>"
ROS_AUTHOR = "Mike Purvis <mpurvis@clearpathrobotics.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "um7"
ROS_BPN = "um7"

ROS_BUILD_DEPENDS = " \
    message-generation \
    roscpp \
    sensor-msgs \
    serial \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    roscpp \
    sensor-msgs \
    serial \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    message-runtime \
    roscpp \
    sensor-msgs \
    serial \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    roslint \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ros-drivers-gbp/um7-release/archive/release/melodic/um7/0.0.4-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "7829e6c6e86f1d9f537823b5f0386c37"
SRC_URI[sha256sum] = "d557326e26d705cb29897eb7ac32baa349a08c71d07cf9501e6c457e3d634349"
S = "${WORKDIR}/um7-release-release-melodic-um7-0.0.4-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('um7', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('um7', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/um7/um7_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/um7/um7-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/um7/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/um7/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

# Copyright (c) 2019 LG Electronics, Inc.

inherit ros_component

# Place metadata here that is unique to components of type "ros1" (as determined by ros_distro__get_component_type())

python __anonymous() {
    bb.warn("catkin.bbclass is deprecated, please use ros_catkin.bbclass instead")
}

inherit ros_catkin

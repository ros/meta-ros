# Copyright (c) 2019 LG Electronics, Inc.

ALLOW_EMPTY_${PN} = "1"

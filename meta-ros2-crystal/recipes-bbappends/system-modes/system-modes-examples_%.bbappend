# Copyright (c) 2019 LG Electronics, Inc.

FILES_${PN}_prepend = "${datadir}/example_modes.yaml "

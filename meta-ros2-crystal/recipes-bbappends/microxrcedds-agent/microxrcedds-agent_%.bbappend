# Copyright (c) 2019 LG Electronics, Inc.

# Silence this:
# ERROR: microxrcedds-agent-1.0.3-1-r0 do_package_qa: QA Issue: non -dev/-dbg/nativesdk- package contains symlink .so: \
#   microxrcedds-agent path '.../usr/lib/libmicroxrcedds_agent.so' [dev-so]
inherit ros-insane

# Copyright (c) 2019 LG Electronics, Inc.

# Without this, apriltag_INCLUDE_DIRS is empty.
export PKG_CONFIG_ALLOW_SYSTEM_CFLAGS = "1"

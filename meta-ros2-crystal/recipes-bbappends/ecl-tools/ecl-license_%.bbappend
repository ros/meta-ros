# Copyright (c) 2019 LG Electronics, Inc.

FILES_${PN}-doc_prepend = "${datadir}/licenses "

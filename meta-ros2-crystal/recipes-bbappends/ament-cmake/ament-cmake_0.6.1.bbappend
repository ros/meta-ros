# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    ament-package-native \
    python3-catkin-pkg-native \
"

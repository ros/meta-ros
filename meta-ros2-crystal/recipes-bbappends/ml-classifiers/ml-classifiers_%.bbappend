# Copyright (c) 2019 LG Electronics, Inc.

# XXX Temp until superflore fixed.
ROS_BUILD_TYPE = "ament_cmake"

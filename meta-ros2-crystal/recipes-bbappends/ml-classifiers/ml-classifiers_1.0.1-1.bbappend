# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILD_DEPENDS_ros2-distro += " \
    rclcpp \
"

ROS_BUILDTOOL_DEPENDS_ros2-distro += " \
    rosidl-adapter-native \
    rosidl-default-generators-native \
"

# Copyright (c) 2019 LG Electronics, Inc.

DEPENDS_remove = "rosidl-cmake"

ROS_BUILDTOOL_DEPENDS += " \
    rosidl-cmake-native \
"

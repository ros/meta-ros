# Copyright (c) 2019 LG Electronics, Inc.

ROS_UNRESOLVED_PLATFORM_PKG_micro-xrce-dds-agent = "microxrcedds-agent"

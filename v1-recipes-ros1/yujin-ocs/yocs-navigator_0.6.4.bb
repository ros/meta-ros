DESCRIPTION = "Navigation module for robots"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "rospy roscpp actionlib tf yocs-math-toolkit move-base-msgs nav-msgs yocs-msgs"

require yujin-ocs.inc

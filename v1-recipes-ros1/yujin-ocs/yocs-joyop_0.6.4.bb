DESCRIPTION = "Joystick teleoperation for your robot core"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "roscpp geometry-msgs sensor-msgs std-msgs yocs-msgs ecl-exceptions ecl-time"

require yujin-ocs.inc

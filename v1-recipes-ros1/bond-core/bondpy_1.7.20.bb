DESCRIPTION = "Python implementation of bond, a mechanism for checking when another process has terminated."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "bond rospy smclib"

require bond-core.inc

DESCRIPTION = "Provides an extensible and standardised framework for input-output devices."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-license ecl-config ecl-errors ecl-mpl ecl-type-traits ecl-utilities ecl-containers ecl-threads"

require ecl-core.inc

DESCRIPTION = "Includes various supporting tools and utilities for c++ programming."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-license ecl-mpl ecl-concepts"

require ecl-core.inc

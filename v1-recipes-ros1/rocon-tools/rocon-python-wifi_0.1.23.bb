DESCRIPTION = "Copy of the pythonwifi package re-packaged and distributed in rocon_tools for use in ROS"
SECTION = "devel"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=fe8b75cf0aba647401e1038bcd69ee74"

DEPENDS = "${PYTHON_PN}-catkin-pkg"

require rocon-tools.inc

DESCRIPTION = "ROS driver for a generic Linux joystick."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=4;endline=4;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "diagnostic-updater rosbag roscpp sensor-msgs"

require joystick-drivers.inc

DESCRIPTION = "Collection of cmake/make build tools primarily for ecl development itself"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-license"

require ecl-tools.inc

DESCRIPTION = "C++ driver library for Kobuki"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-build ecl-mobile-robot ecl-converters ecl-devices ecl-geometry ecl-sigslots ecl-time ecl-command-line"

require kobuki-core.inc

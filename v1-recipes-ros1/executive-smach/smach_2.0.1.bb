DESCRIPTION = "SMACH is a task-level architecture for rapidly creating complex robot behavior."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=d566ef916e9dedc494f5f793a6690ba5"

require executive-smach.inc

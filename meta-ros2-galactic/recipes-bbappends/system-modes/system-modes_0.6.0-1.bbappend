# Copyright (c) 2020 LG Electronics, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    rosidl-adapter-native \
    rosidl-default-generators-native \
    rosidl-parser-native \
    python3-empy-native \
    python3-numpy-native \
    python3-lark-parser-native \
    rosidl-typesupport-fastrtps-c-native \
    rosidl-typesupport-fastrtps-cpp-native \
"

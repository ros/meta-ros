# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILD_DEPENDS_remove = "ament-cmake"
ROS_BUILDTOOL_DEPENDS += "ament-cmake-native"

# Copyright (c) 2019 LG Electronics, Inc.

DEPENDS += " \
    osrf-testing-tools-cpp \
"

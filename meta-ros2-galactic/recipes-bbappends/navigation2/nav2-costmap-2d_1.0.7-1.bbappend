# Copyright (c) 2021 LG Electronics, Inc.

# nav2-costmap-2d/1.0.0-2-r0/git/plugins/inflation_layer.cpp:164:14: error: format '%lu' expects argument of type 'long unsigned int', but argument 5 has type 'std::vector<geometry_msgs::msg::Point_<std::allocator<void> > >::size_type' {aka 'unsigned int'} [-Werror=format=]
CXXFLAGS += "-Wno-error=format="

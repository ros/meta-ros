# Copyright (c) 2021 LG Electronics, Inc.

ROS_EXEC_DEPENDS:remove = "${PYTHON_PN}-enum34"

# Copyright (c) 2021 LG Electronics, Inc.

# nav2-waypoint-follower/1.0.0-2-r0/temp/log.do_compile.41941:/jenkins/mjansa/build/ros/webos-galactic-honister/tmp-glibc/work/qemux86-webos-linux/nav2-waypoint-follower/1.0.0-2-r0/git/src/waypoint_follower.cpp:256:25: error: format '%lu' expects argument of type 'long unsigned int', but argument 5 has type 'std::vector<geometry_msgs::msg::PoseStamped_<std::allocator<void> >, std::allocator<geometry_msgs::msg::PoseStamped_<std::allocator<void> > > >::size_type' {aka 'unsigned int'} [-Werror=format=]
CXXFLAGS += "-Wno-error=format="

# Copyright (c) 2021 LG Electronics, Inc.

# nav2-bt-navigator/1.0.0-2-r0/temp/log.do_compile.20862:/jenkins/mjansa/build/ros/webos-galactic-honister/tmp-glibc/work/qemux86-webos-linux/nav2-bt-navigator/1.0.0-2-r0/git/src/navigators/navigate_through_poses.cpp:194:16: error: format '%li' expects argument of type 'long int', but argument 5 has type 'std::vector<geometry_msgs::msg::PoseStamped_<std::allocator<void> >, std::allocator<geometry_msgs::msg::PoseStamped_<std::allocator<void> > > >::size_type' {aka 'unsigned int'} [-Werror=format=]
CXXFLAGS += "-Wno-error=format="

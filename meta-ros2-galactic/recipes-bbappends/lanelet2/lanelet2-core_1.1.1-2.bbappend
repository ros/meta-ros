# Copyright (c) 2021 LG Electronics, Inc.

# ERROR: lanelet2-core-1.1.1-1-r0 do_package_qa: QA Issue: non -dev/-dbg/nativesdk- package contains symlink .so: lanelet2-core path '/work/qemux86-webos-linux/lanelet2-core/1.1.1-1-r0/packages-split/lanelet2-core/usr/lib/liblanelet2_core.so' [dev-so]
inherit ros_insane_dev_so

# Copyright (c) 2021 LG Electronics, Inc.

# backport equivalent of following changes:
# dashing: https://github.com/ros/rosdistro/commit/e27c2fdadc560e6ecf653d73d01d3cff10bda49e
# foxy: https://github.com/ros/rosdistro/commit/ef8ab3a3d8ca3b9de81807050f22ec4a300fb6f2
SRC_URI = "git://github.com/ros2-gbp/fmi_adapter-release;${ROS_BRANCH};protocol=https"

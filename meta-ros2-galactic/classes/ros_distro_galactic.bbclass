# Every ROS recipe, generated or not, must contain "inherit ros_distro_${ROS_DISTRO}".
#
# Copyright (c) 2021 LG Electronics, Inc.

ROS_DISTRO = "galactic"

inherit ${ROS_DISTRO_TYPE}_distro

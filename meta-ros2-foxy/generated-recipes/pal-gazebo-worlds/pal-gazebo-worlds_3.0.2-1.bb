# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_foxy
inherit ros_superflore_generated

DESCRIPTION = "Simulation worlds for PAL robots."
AUTHOR = "Victor Lopez <victor.lopez@pal-robotics.com>"
ROS_AUTHOR = "Victor Lopez <victor.lopez@pal-robotics.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "LGPL-3.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=a8c41fd6b72c7d3bd996ba4f3d34a6ae"

ROS_CN = "pal_gazebo_worlds"
ROS_BPN = "pal_gazebo_worlds"

ROS_BUILD_DEPENDS = " \
    ament-cmake-auto \
    gazebo-msgs \
    rclcpp \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    gazebo-msgs \
    rclcpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    gazebo-msgs \
    gazebo-ros \
    rclcpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/pal-gbp/pal_gazebo_worlds-ros2-release/archive/release/foxy/pal_gazebo_worlds/3.0.2-1.tar.gz
ROS_BRANCH ?= "branch=release/foxy/pal_gazebo_worlds"
SRC_URI = "git://github.com/pal-gbp/pal_gazebo_worlds-ros2-release;${ROS_BRANCH};protocol=https"
SRCREV = "f5f0902bd41d51ed8ab1320e1d6b62696cc9527b"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

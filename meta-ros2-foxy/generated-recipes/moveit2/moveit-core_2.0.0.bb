# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_foxy
inherit ros_superflore_generated

DESCRIPTION = "Core libraries used by MoveIt!"
AUTHOR = "Dave Coleman <dave@picknik.ai>"
ROS_AUTHOR = "Ioan Sucan <isucan@google.com>"
HOMEPAGE = "http://moveit.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=68b329da9893e34099c7d8ad5cb9c940"

ROS_CN = "moveit"
ROS_BPN = "moveit_core"

ROS_BUILD_DEPENDS = " \
    rclcpp \
    rclcpp-components \
    common-interfaces \
    moveit-common \
    assimp \
    boost \
    libeigen \
    bullet \
    eigen-stl-containers \
    geometric-shapes \
    geometry-msgs \
    kdl-parser \
    urdf \
    urdfdom \
    urdfdom-headers \
    moveit-msgs \
    octomap \
    octomap-msgs \
    random-numbers \
    sensor-msgs \
    shape-msgs \
    srdfdom \
    std-msgs \
    tf2 \
    tf2-eigen \
    tf2-geometry-msgs \
    trajectory-msgs \
    visualization-msgs \
    tf2-kdl \
    pluginlib \
    fcl \
    python3-empy \
    rcutils \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-ros-native \
    pkgconfig-native \
    eigen3-cmake-module-native \
    rosidl-default-generators-native \
"

ROS_EXPORT_DEPENDS = " \
    rclcpp \
    common-interfaces \
    moveit-common \
    assimp \
    boost \
    libeigen \
    bullet \
    eigen-stl-containers \
    geometric-shapes \
    geometry-msgs \
    kdl-parser \
    urdf \
    urdfdom \
    urdfdom-headers \
    moveit-msgs \
    octomap \
    octomap-msgs \
    random-numbers \
    sensor-msgs \
    shape-msgs \
    srdfdom \
    std-msgs \
    tf2 \
    tf2-eigen \
    tf2-geometry-msgs \
    trajectory-msgs \
    visualization-msgs \
    tf2-kdl \
    pluginlib \
    fcl \
    python3-empy \
    rcutils \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    rclcpp \
    common-interfaces \
    moveit-common \
    assimp \
    boost \
    libeigen \
    bullet \
    eigen-stl-containers \
    geometric-shapes \
    geometry-msgs \
    kdl-parser \
    urdf \
    urdfdom \
    urdfdom-headers \
    moveit-msgs \
    octomap \
    octomap-msgs \
    random-numbers \
    sensor-msgs \
    shape-msgs \
    srdfdom \
    std-msgs \
    tf2 \
    tf2-eigen \
    tf2-geometry-msgs \
    trajectory-msgs \
    visualization-msgs \
    tf2-kdl \
    pluginlib \
    fcl \
    python3-empy \
    rcutils \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    angles \
    code-coverage \
    moveit-resources \
    orocos-kdl \
    rosunit \
    tf2-kdl \
"
LDFLAGS = "-lpthread"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

ROS_BRANCH ?= "branch=main"
SRC_URI = "git://github.com/ros-planning/moveit2.git;${ROS_BRANCH};protocol=https;"
SRCREV = "d8b5137ef72315603e406a2ce5215cc1b1c03eef"
S = "${WORKDIR}/git/moveit_core"

# fix QA Issue: non -dev/-dbg/nativesdk- package contains symlink .so: moveit-core path 
# https://yocto.yoctoproject.narkive.com/HbIp8MGK/understanding-dev-package-contains-non-symlink
INSANE_SKIP_${PN} += "dev-so"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

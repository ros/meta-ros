# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_foxy
inherit ros_superflore_generated

DESCRIPTION = "PlotJuggler: juggle with data"
AUTHOR = "Davide Faconti <davide.faconti@gmail.com>"
ROS_AUTHOR = "Davide Faconti <davide.faconti@gmail.com>"
HOMEPAGE = "https://github.com/facontidavide/PlotJuggler"
SECTION = "devel"
LICENSE = "LGPL-2"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=406b3609bd6d5a41e48fc30c8875886f"

ROS_CN = "plotjuggler"
ROS_BPN = "plotjuggler"

ROS_BUILD_DEPENDS = " \
    ${ROS_UNRESOLVED_PLATFORM_PKG_binutils} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libqt5-svg-dev} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libqt5multimedia5-plugins} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_qtdeclarative5-dev} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_qtmultimedia5-dev} \
    boost \
    fastcdr \
    geometry-msgs \
    nav-msgs \
    plotjuggler-msgs \
    qtbase \
    rclcpp \
    rcpputils \
    rosbag2 \
    rosbag2-transport \
    sensor-msgs \
    tf2-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    ${ROS_UNRESOLVED_PLATFORM_PKG_binutils} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libqt5-svg-dev} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libqt5multimedia5-plugins} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_qtdeclarative5-dev} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_qtmultimedia5-dev} \
    boost \
    fastcdr \
    geometry-msgs \
    nav-msgs \
    plotjuggler-msgs \
    qtbase \
    rclcpp \
    rcpputils \
    rosbag2 \
    rosbag2-transport \
    sensor-msgs \
    tf2-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ${ROS_UNRESOLVED_PLATFORM_PKG_binutils} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libqt5-svg-dev} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libqt5multimedia5-plugins} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_qtdeclarative5-dev} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_qtmultimedia5-dev} \
    boost \
    fastcdr \
    geometry-msgs \
    nav-msgs \
    plotjuggler-msgs \
    qtbase \
    rclcpp \
    rcpputils \
    rosbag2 \
    rosbag2-transport \
    sensor-msgs \
    tf2-msgs \
    tf2-ros \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/facontidavide/plotjuggler-release/archive/release/foxy/plotjuggler/2.8.4-1.tar.gz
ROS_BRANCH ?= "branch=release/foxy/plotjuggler"
SRC_URI = "git://github.com/facontidavide/plotjuggler-release;${ROS_BRANCH};protocol=https"
SRCREV = "f1f283a838e89297d5636ef442dc45447df71da3"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Copyright (c) 2020 LG Electronics, Inc.

EXTRA_OECMAKE += "-DSPDLOG_BUILD_SHARED=on"

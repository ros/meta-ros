# Copyright (c) 2021 Intel Corp.

ROS_EXEC_DEPENDS:remove = "ceres-solver"

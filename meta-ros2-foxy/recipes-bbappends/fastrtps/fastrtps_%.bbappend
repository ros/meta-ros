# Copyright (c) 2019-2021 LG Electronics, Inc.

inherit ros_insane_dev_so

FILES_${PN} += "${prefix}/tools"

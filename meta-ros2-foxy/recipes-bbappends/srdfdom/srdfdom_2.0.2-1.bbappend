# Copyright (c) 2021 LG Electronics, Inc.

# ERROR: srdfdom-2.0.0-1-r0 do_package_qa: QA Issue:
# non -dev/-dbg/nativesdk- package contains symlink .so: srdfdom path '/work/raspberrypi4-webos-linux-gnueabi/srdfdom/2.0.0-1-r0/packages-split/srdfdom/usr/lib/libsrdfdom.so' [dev-so]
inherit ros_insane_dev_so

# Copyright (c) 2020-2021 LG Electronics, Inc.

ROS_BUILD_DEPENDS += " \
    fastcdr \
    fastrtps \
    fastrtps-cmake-module \
    rosidl-generator-c \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    rcutils \
    rmw \
    rosidl-typesupport-fastrtps-c-native \
    rosidl-typesupport-fastrtps-cpp-native \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
"

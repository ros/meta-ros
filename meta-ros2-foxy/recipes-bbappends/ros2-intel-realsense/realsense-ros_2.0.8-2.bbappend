# Copyright (c) 2020 LG Electronics, Inc.

DEPENDS += "opencv rosidl-adapter"

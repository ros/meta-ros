# Copyright (c) 2020 LG Electronics, Inc.

# spdlog is header only library and PN is empty, so it wasn't created
RDEPENDS_${PN}_remove = "spdlog"

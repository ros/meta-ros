# Copyright (c) 2020 LG Electronics, Inc.

# ERROR: kobuki-core-1.3.1-1-r0 do_package_qa: QA Issue: non -dev/-dbg/nativesdk- package contains symlink .so: kobuki-core path '/work/qemux86-webos-linux/kobuki-core/1.3.1-1-r0/packages-split/kobuki-core/usr/lib/libkobuki_core.so' [dev-so]
inherit ros_insane_dev_so

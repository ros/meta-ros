# Copyright (c) 2020 LG Electronics, Inc.

ROS_EXEC_DEPENDS += " \
    ${PYTHON_PN}-multiprocessing \
"

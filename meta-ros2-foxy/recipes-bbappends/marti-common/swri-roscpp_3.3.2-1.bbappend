# Copyright (c) 2019 LG Electronics, Inc.

FILES_${PN} += "${prefix}/launch"

# Copyright (c) 2020 LG Electronics, Inc.

FILES_${PN}-doc_prepend = "${datadir}/licenses "

# Copyright (c) 2020 LG Electronics, Inc.

ROS_BUILD_DEPENDS += " \
    rosidl-typesupport-fastrtps-c-native \
    rosidl-typesupport-fastrtps-cpp-native \
"

ROS_BUILD_DEPENDS += " \
    python3-lark-parser-native \
    python3-numpy-native \
    rosidl-adapter-native \
    rosidl-parser-native \
    rpyutils-native \
"

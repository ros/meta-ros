require python-catkin-tools.inc

inherit setuptools3

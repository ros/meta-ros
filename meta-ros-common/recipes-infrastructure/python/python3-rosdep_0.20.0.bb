FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

require python-rosdep.inc

inherit setuptools3

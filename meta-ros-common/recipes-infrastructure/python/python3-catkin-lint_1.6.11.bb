require python-catkin-lint.inc

inherit setuptools3

LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"

SRC_URI = "git://github.com/resurrecting-open-source-projects/stress;protocol=https;branch=master"

SRCREV = "f725109e8b98260933fdca7cf8166e017311bac4"

inherit autotools

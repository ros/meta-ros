SUMMARY = "Parses JUnit/xUnit Result XML files with ease"
HOMEPAGE = "https://junitparser.readthedocs.io"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=2d00702cde917dd61c41041bc30136dd"

SRC_URI = "git://github.com/weiwei/junitparser;protocol=https;branch=master"

SRCREV = "5bdff46601ec082b9ab0601c68bf5d3af6672577"

inherit python_setuptools_build_meta

# Copyright (c) 2019 LG Electronics, Inc.

require python-pydot.inc

inherit setuptools3

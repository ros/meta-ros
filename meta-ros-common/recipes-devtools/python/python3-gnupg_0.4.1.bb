# Copyright (c) 2019 LG Electronics, Inc.

require python-gnupg.inc
inherit setuptools3

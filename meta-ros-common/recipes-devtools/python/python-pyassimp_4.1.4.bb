require python-pyassimp.inc

inherit setuptools

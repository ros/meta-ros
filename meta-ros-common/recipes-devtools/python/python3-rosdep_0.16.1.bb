FILESEXTRAPATHS_prepend := "${THISDIR}/python-rosdep:"

require python-rosdep.inc

inherit setuptools3

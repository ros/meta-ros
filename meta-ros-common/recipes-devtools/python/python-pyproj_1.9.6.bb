include python-pyproj.inc

inherit setuptools

# Copyright (c) 2019 LG Electronics, Inc.

BBCLASSEXTEND += "native"

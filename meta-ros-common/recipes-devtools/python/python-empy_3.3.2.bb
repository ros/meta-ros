require python-empy.inc

inherit distutils

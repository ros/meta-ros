# Copyright (c) 2023 Wind River Systems, Inc.

BBCLASSEXTEND = "native nativesdk"

SUMMARY = "Lossless conversion of raster images to PDF."
HOMEPAGE = "https://gitlab.mister-muffin.de/josch/img2pdf.git"
LICENSE = "GPL-3.0-or-later"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3000208d539ec061b899bce1d9ce9404"

SRC_URI[md5sum] = "c1176cd564abe97b85f4968e45ad6c46"
SRC_URI[sha256sum] = "ae6c19731bde2551356c178bf356ca118ac32a232c737a14b423f8039df3c24b"

inherit pypi setuptools3

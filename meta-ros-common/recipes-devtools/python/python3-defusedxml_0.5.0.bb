require python-defusedxml.inc

inherit setuptools3

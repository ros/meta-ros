require python-rosdistro.inc

inherit setuptools

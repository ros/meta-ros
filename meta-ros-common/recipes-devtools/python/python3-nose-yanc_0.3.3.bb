# Copyright (c) 2019 LG Electronics, Inc.

require python-nose-yanc.inc

inherit setuptools3

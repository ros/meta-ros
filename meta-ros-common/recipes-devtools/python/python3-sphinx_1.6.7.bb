# Copyright (c) 2019 LG Electronics, Inc.

require python-sphinx.inc

inherit setuptools3

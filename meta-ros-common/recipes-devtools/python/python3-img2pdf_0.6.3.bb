SUMMARY = "Lossless conversion of raster images to PDF."
HOMEPAGE = "https://gitlab.mister-muffin.de/josch/img2pdf.git"
LICENSE = "GPL-3.0-or-later"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3000208d539ec061b899bce1d9ce9404"

SRC_URI[sha256sum] = "219518020f5bd242bdc46493941ea3f756f664c2e86f2454721e74353f58cd95"

inherit pypi python_flit_core

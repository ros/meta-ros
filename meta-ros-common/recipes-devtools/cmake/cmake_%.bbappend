FILES:${PN}-dev:class-nativesdk = ""

inherit pypi setuptools3
require python-pydot.inc

inherit pypi setuptools
require python-pydot.inc

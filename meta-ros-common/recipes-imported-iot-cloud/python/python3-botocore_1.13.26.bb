inherit setuptools3
require python-botocore.inc

inherit setuptools3
require python-boto3.inc

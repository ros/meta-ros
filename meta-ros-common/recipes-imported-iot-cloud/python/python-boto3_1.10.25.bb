inherit setuptools
require python-boto3.inc

inherit setuptools
require python-botocore.inc

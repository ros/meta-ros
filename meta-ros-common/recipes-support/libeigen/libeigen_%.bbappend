# Copyright (c) 2019 LG Electronics, Inc.

# libeigen is a template library, ie, source-only.
ALLOW_EMPTY:${PN} = "1"

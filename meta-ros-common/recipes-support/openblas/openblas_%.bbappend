PACKAGECONFIG = "lapack cblas affinity dynarch"

# It needs fortran compiler and we do not enable fortran with clang yet
TOOLCHAIN = "gcc"

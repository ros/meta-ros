# Copyright (c) 2020 LG Electronics, Inc.

# Backport https://lists.openembedded.org/g/openembedded-devel/message/86162
RDEPENDS:${PN}:remove:class-native = "gcov gcov-symlinks"

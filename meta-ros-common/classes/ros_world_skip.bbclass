# Copyright (c) 2026 Wind River Systems, Inc.
#
# For packagegroups that list a lot of ROS packages: leave out the ones that are skipped with
# SKIP_RECIPE, so that "bitbake world" doesn't fail on a runtime dependency on a recipe that isn't
# there. The SKIP_RECIPE entries are mostly generated by scripts/generate-world-skips.py.

python __anonymous() {
    pn = d.getVar('PN')
    deps = (d.getVar('RDEPENDS:' + pn) or '').split()
    keep = [dep for dep in deps if not d.getVarFlag('SKIP_RECIPE', dep)]
    if len(keep) != len(deps):
        d.setVar('RDEPENDS:' + pn, ' '.join(keep))
}

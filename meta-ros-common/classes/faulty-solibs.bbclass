python __anonymous() {
    bb.warn("faulty-solibs.bbclass is deprecated, please use ros_faulty_solibs.bbclass instead")
}

inherit ros_faulty_solibs

# Metadata common to all ROS distro types.
#
# Copyright (c) 2019 LG Electronics, Inc.

DISTROOVERRIDES .= ":${ROS_DISTRO_BASELINE_PLATFORM}:${ROS_DISTRO_TYPE}-distro:${ROS_DISTRO}"

python __anonymous() {
    bb.warn("ros-insane.bbclass is deprecated, please use ros_insane_dev_so.bbclass instead")
}

inherit ros_insane_dev_so

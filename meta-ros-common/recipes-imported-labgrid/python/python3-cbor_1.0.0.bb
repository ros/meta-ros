# Imported as-is from
# https://github.com/labgrid-project/meta-labgrid/commit/7b3b31b953d954d88f6cde4cd95e1efd6e53b1a3

inherit setuptools3
require python-cbor.inc

SRC_URI[sha256sum] = "13225a262ddf5615cbd9fd55a76a0d53069d18b07d2e9f19c39e6acb8609bbb6"

# Imported as-is from
# https://github.com/labgrid-project/meta-labgrid/commit/0bdddba7449375b809b9f470318f4538dda27283

inherit setuptools3
require python-snappy.inc

SRC_URI[md5sum] = "0c06bbed70a8390b55a60f5ee79a27d2"
SRC_URI[sha256sum] = "385fb216e7d1241f70c14c2bea3f042ec235caa65d708294f1ece50d3efa5de3"

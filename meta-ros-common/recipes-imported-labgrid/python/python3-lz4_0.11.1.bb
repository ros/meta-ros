# Imported as-is from
# https://github.com/labgrid-project/meta-labgrid/commit/db27f76b40bb4f25ddd69ab3421c1d92e996868e

inherit setuptools3
require python-lz4.inc

SRC_URI[md5sum] = "2a7d1d8669046c380ad69dbd9db4db94"
SRC_URI[sha256sum] = "440bbb039e15c09b049c0a8c1294978341d3fac943b83e04ff3f9e3b7ec0058b"

# Imported as-is from
# https://github.com/labgrid-project/meta-labgrid/commit/394060f82e3c00d5ec665b5f76b090e1d5d7a808

inherit setuptools3
require python-u-msgpack-python.inc

SRC_URI[md5sum] = "8c2a628b26f7e2d5857fdddeca8478a0"
SRC_URI[sha256sum] = "2f31fc1b6dd8632c230ea7012470e40f77119f20999274dda6f1afa9c305e590"

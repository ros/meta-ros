# Imported as-is from
# https://github.com/labgrid-project/meta-labgrid/commit/74c43def975a32a5310af4441d6e8d86c85a6d71

inherit setuptools3
require python-py-ubjson.inc

SRC_URI[sha256sum] = "81784e64936c12e218afc49ff4fb90702f298ac16848971d9570c87595860762"

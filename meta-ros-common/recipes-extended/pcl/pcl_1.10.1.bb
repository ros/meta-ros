# Copyright (c) 2021 LG Electronics, Inc.

require pcl.inc

SRC_URI += "file://0001-MovingLeastSquares-reduce-the-number.patch"

SRCREV = "cbed174ba0a0c9ef021015d54d3b60320d808593"

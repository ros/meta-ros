# Copyright (c) 2021 LG Electronics, Inc.
# Copyright (c) 2024 Wind River Systems, Inc.

require pcl.inc

PV = "1.14.1+git"
SRCREV = "1590ba5f6b8738d308fca8657dcec509f4537225"

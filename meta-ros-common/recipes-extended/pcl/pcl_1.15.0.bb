# Copyright (c) 2021 LG Electronics, Inc.
# Copyright (c) 2024 Wind River Systems, Inc.

require pcl.inc

SRCREV = "605cdd5b1b971d3e90c737aaae947bbba41b66e7"

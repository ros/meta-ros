inherit setuptools3
require python-mypy-native.inc

SRC_URI[md5sum] = "ae3f2772193f0bfe0f7182993daef051"
SRC_URI[sha256sum] = "49925f9da7cee47eebf3420d7c0e00ec662ec6abb2780eb0a16260a7ba25f9c4"

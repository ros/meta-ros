inherit setuptools3
require python-typed-ast-native.inc

SRC_URI[md5sum] = "9a3dd35e136427313465faa75f3110da"
SRC_URI[sha256sum] = "66480f95b8167c9c5c5c87f32cf437d585937970f3fc24386f313a4c97b44e34"

inherit setuptools3
require python-mypy-extensions-native.inc

SRC_URI[md5sum] = "d14d945e5c54e7a61607e00fcfdbbcd5"
SRC_URI[sha256sum] = "37e0e956f41369209a3d5f34580150bcacfabaa57b33a15c0b25f4b5725e0812"

inherit setuptools3
require python-typing-extensions-native.inc

SRC_URI[md5sum] = "98510adbacf8ea74f46f98b0a5cbdf73"
SRC_URI[sha256sum] = "2ed632b30bb54fc3941c382decfd0ee4148f5c591651c9272473fea2c6397d95"

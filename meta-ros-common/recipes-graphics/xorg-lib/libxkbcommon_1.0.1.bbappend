# Backport fix from https://lists.openembedded.org/g/openembedded-core/message/144246
DEPENDS += "libxml2"

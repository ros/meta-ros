require meta-ros-image-ptest-all.bb

DESCRIPTION = "Recipe to trigger execution of all fast meta-ros ptest images."

PTESTS_META_ROS = "${PTESTS_FAST_META_ROS}"


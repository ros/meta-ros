# Update the GitLab repo URL and set the branch to main
SRC_URI = "git://gitlab.dkrz.de/dkrz-sw/libaec.git;protocol=https;branch=main"
SRCREV = "d84ea9c83097a0806f73fc48b69ae7eb9a94525e"

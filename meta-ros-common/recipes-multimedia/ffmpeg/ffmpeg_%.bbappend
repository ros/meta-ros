# Copyright (c) 2024 Wind River Systems, Inc.
BBCLASSEXTEND = "native nativesdk"

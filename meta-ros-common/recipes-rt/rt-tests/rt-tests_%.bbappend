# Copyright (c) 2020 LG Electronics, Inc.

# Backport COMPATIBLE_HOST restriction from:
# https://lists.openembedded.org/g/openembedded-core/message/144242

COMPATIBLE_HOST = "(i.86.*|x86_64.*|powerpc64.*)-linux"

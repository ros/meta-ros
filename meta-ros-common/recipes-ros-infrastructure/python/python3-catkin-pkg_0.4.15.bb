require python-catkin-pkg.inc

inherit setuptools3

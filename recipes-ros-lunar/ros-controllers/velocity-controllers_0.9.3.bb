DESCRIPTION = "velocity_controllers."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "angles control-msgs control-toolbox controller-interface forward-command-controller realtime-tools urdf"

require ros-controllers.inc

DESCRIPTION = "ROS message definitions for Velodyne 3D LIDARs."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "message-generation message-runtime std-msgs roscpp-serialization"

require velodyne.inc

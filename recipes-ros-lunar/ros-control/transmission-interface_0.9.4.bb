DESCRIPTION = "Transmission Interface."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=68b329da9893e34099c7d8ad5cb9c940"

DEPENDS = "hardware-interface cmake-modules libtinyxml pluginlib resource-retriever roscpp"

require ros-control.inc

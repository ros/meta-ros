DESCRIPTION = "This package contains step-by-step tutorials written in C++ for learning ROS."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "message-generation roscpp rosconsole roscpp-serialization rostime std-msgs"

require ros-tutorials.inc

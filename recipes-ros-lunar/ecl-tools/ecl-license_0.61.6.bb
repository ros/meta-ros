DESCRIPTION = "Maintains the ecl licenses and also provides an install target \
  for deploying licenses with the ecl libraries."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

require ecl-tools.inc

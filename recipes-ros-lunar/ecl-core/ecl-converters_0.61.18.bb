DESCRIPTION = "Some fast/convenient type converters, mostly for char strings or strings."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-license ecl-config ecl-errors ecl-exceptions ecl-mpl ecl-type-traits ecl-concepts"

require ecl-core.inc

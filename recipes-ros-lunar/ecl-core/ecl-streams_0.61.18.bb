DESCRIPTION = "These are lightweight text streaming classes that connect to standardised ecl type devices."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-license ecl-errors ecl-concepts ecl-devices ecl-time ecl-converters ecl-type-traits"

require ecl-core.inc

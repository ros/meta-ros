DESCRIPTION = "This includes a suite of programs demo'ing various aspects of the ecl_core."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-build ecl-license ecl-config ecl-linear-algebra ecl-command-line ecl-converters ecl-containers ecl-devices ecl-errors ecl-exceptions ecl-formatters ecl-geometry ecl-ipc ecl-sigslots ecl-streams ecl-threads ecl-type-traits ecl-time-lite"

require ecl-core.inc

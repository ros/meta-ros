DESCRIPTION = "Introduces a compile time concept checking mechanism that can be used \
  most commonly to check for required functionality when passing template arguments."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-license ecl-config ecl-type-traits"

require ecl-core.inc

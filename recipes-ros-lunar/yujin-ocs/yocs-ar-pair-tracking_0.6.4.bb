DESCRIPTION = "The AR pair tracking package."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "roscpp std-msgs geometry-msgs sensor-msgs yocs-math-toolkit ar-track-alvar-msgs yocs-ar-marker-tracking yocs-msgs"

require yujin-ocs.inc

DESCRIPTION = "Simple tool for waypoints navigation"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "tf roscpp actionlib nav-msgs geometry-msgs move-base-msgs actionlib-msgs visualization-msgs yocs-math-toolkit yocs-msgs"

require yujin-ocs.inc

DESCRIPTION = "rosmsg contains two command-line tools: rosmsg and rossrv. \
rosmsg is a command-line tool for displaying information about ROS Message \
types. rossrv is a command-line tool for displaying information about ROS Service types."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=d566ef916e9dedc494f5f793a6690ba5"

require ros-comm.inc

ROS_PKG_SUBDIR = "tools"

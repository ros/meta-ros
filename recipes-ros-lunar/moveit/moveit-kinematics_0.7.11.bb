DESCRIPTION = "Package for all inverse kinematics solvers in MoveIt!"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "moveit-core moveit-ros-planning"

require moveit.inc

ROS_BPN = "moveit_kinematics"

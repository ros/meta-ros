DESCRIPTION = "Components of MoveIt used for manipulation"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "moveit-core moveit-ros-planning moveit-ros-move-group moveit-msgs manipulation-msgs"

require moveit.inc

ROS_BPN = "moveit_ros/manipulation"

DESCRIPTION = "This planner attempts to find a legal place to put a carrot for the robot to follow."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=01c2bc31767ccb3a68e12f02612b2a97"

DEPENDS = "base-local-planner costmap-2d libeigen nav-core pluginlib roscpp tf"

require navigation.inc

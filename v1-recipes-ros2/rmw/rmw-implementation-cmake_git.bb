SUMMARY = "CMake functions which can discover and enumerate available implementations."
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

include rmw.inc

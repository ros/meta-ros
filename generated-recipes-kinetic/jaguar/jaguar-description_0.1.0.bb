# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "A robot description package for Dr Robot's Jaguar 4x4"
AUTHOR = "George Stavrinos <gstavrinos@iit.demokritos.gr>"
ROS_AUTHOR = "George Stavrinos <gstavrinos@iit.demokritos.gr>"
HOMEPAGE = "http://wiki.ros.org/jaguar"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "jaguar"
ROS_BPN = "jaguar_description"

ROS_BUILD_DEPENDS = " \
    roscpp \
    tf \
    urdf \
    xacro \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    roscpp \
    tf \
    urdf \
    xacro \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    roscpp \
    tf \
    urdf \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/gstavrinos/jaguar-release/archive/release/kinetic/jaguar_description/0.1.0-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "bfba82faf9e55de00d5ac253d14694ac"
SRC_URI[sha256sum] = "e18b6815a1f4e2bfa9e27f96b7513f23c31a08394fae025f003eb340a51b6b66"
S = "${WORKDIR}/jaguar-release-release-kinetic-jaguar_description-0.1.0-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('jaguar', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('jaguar', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/jaguar/jaguar_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/jaguar/jaguar-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/jaguar/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/jaguar/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

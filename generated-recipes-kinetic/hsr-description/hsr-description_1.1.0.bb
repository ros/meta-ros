# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "URDF files for Toyota HSR"
AUTHOR = "Koji Terada <koji_terada@mail.toyota.co.jp>"
ROS_AUTHOR = "Akiyoshi Ochiai"
HOMEPAGE = "None"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=a78e00dd31d2a6549fa750de03479aed"

ROS_CN = "hsr_description"
ROS_BPN = "hsr_description"

ROS_BUILD_DEPENDS = " \
    rosbash \
    xacro \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    rosbash \
    xacro \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    hsr-meshes \
    joint-state-publisher \
    robot-state-publisher \
    rosbash \
    rviz \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ToyotaResearchInstitute/hsr_description-release/archive/release/kinetic/hsr_description/1.1.0-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "13e3dac5c7c2bb71cb34a62078b20a97"
SRC_URI[sha256sum] = "0404fdb0e9b922ce077ecead23b4631406e9d24d7dcf7afd48b16818f2e5e138"
S = "${WORKDIR}/hsr_description-release-release-kinetic-hsr_description-1.1.0-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('hsr-description', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('hsr-description', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/hsr-description/hsr-description_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/hsr-description/hsr-description-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/hsr-description/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/hsr-description/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "ROS package to detect handles."
AUTHOR = "Andreas ten Pas <atp@ccs.neu.edu>"
HOMEPAGE = "http://wiki.ros.org/handle_detector"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "handle_detector"
ROS_BPN = "handle_detector"

ROS_BUILD_DEPENDS = " \
    cmake-modules \
    eigen-conversions \
    geometry-msgs \
    lapack \
    message-generation \
    pcl-conversions \
    roscpp \
    std-msgs \
    tf \
    tf-conversions \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    cmake-modules \
    eigen-conversions \
    geometry-msgs \
    lapack \
    message-runtime \
    pcl-conversions \
    roscpp \
    std-msgs \
    tf \
    tf-conversions \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    cmake-modules \
    eigen-conversions \
    geometry-msgs \
    lapack \
    message-runtime \
    pcl-conversions \
    roscpp \
    std-msgs \
    tf \
    tf-conversions \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/atenpas/handle_detector-release/archive/release/kinetic/handle_detector/1.3.1-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "5cfd4f6f0ee5bf029a3ca86366f441e8"
SRC_URI[sha256sum] = "33c01a3dac7e8a6d395963ecbbb23d9f0d0face2abadb8eb606f98bfcb0da341"
S = "${WORKDIR}/handle_detector-release-release-kinetic-handle_detector-1.3.1-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('handle-detector', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('handle-detector', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/handle-detector/handle-detector_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/handle-detector/handle-detector-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/handle-detector/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/handle-detector/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

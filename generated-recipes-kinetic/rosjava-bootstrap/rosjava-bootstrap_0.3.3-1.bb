# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Bootstrap utilities for rosjava builds."
AUTHOR = "Daniel Stonier <d.stonier@gmail.com>"
ROS_AUTHOR = "Daniel Stonier"
HOMEPAGE = "http://ros.org/wiki/rosjava_bootstrap"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=3dce4ba60d7e51ec64f3c3dc18672dd3"

ROS_CN = "rosjava_bootstrap"
ROS_BPN = "rosjava_bootstrap"

ROS_BUILD_DEPENDS = " \
    rosjava-build-tools \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    rosjava-build-tools \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    rosjava-build-tools \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/rosjava-release/rosjava_bootstrap-release/archive/release/kinetic/rosjava_bootstrap/0.3.3-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "c1e8bf39c8e44c36eda6f86c60355c93"
SRC_URI[sha256sum] = "7e4eb1a95a616fa7af3c1541ad6abf672dc69b26a36fe9acec545c4b27310bcd"
S = "${WORKDIR}/rosjava_bootstrap-release-release-kinetic-rosjava_bootstrap-0.3.3-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('rosjava-bootstrap', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('rosjava-bootstrap', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rosjava-bootstrap/rosjava-bootstrap_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rosjava-bootstrap/rosjava-bootstrap-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rosjava-bootstrap/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rosjava-bootstrap/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "3D mesh files for the Toyota HSR"
AUTHOR = "Koji Terada <koji_terada@mail.toyota.co.jp>"
ROS_AUTHOR = "Yoshihiro Matsuda"
HOMEPAGE = "None"
SECTION = "devel"
LICENSE = "CC-BY-NC-ND-4.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=cc423ec78844eb7f9a98d5df4d0f6289"

ROS_CN = "hsr_meshes"
ROS_BPN = "hsr_meshes"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = ""

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ToyotaResearchInstitute/hsr_meshes-release/archive/release/kinetic/hsr_meshes/1.1.0-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "d6138a1b88b3aad2077f227cde6fffd7"
SRC_URI[sha256sum] = "1a60d5b55da3a1c9fe719069bb83116a7670362ceca181223313d7709a742aee"
S = "${WORKDIR}/hsr_meshes-release-release-kinetic-hsr_meshes-1.1.0-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('hsr-meshes', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('hsr-meshes', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/hsr-meshes/hsr-meshes_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/hsr-meshes/hsr-meshes-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/hsr-meshes/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/hsr-meshes/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The drone_wrapper package"
AUTHOR = "Nikhil Khedekar <nikhilvkhedekar@gmail.com>"
ROS_AUTHOR = "Nikhil Khedekar <nikhilvkhedekar@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=1a58895467feb5b42724abbf3f0d9612"

ROS_CN = "jderobot_drones"
ROS_BPN = "drone_wrapper"

ROS_BUILD_DEPENDS = " \
    cv-bridge \
    gazebo-ros \
    geometry-msgs \
    mavros \
    mavros-msgs \
    rospy \
    sensor-msgs \
    tf \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    cv-bridge \
    gazebo-ros \
    geometry-msgs \
    mavros \
    mavros-msgs \
    rospy \
    sensor-msgs \
    tf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    cv-bridge \
    gazebo-ros \
    geometry-msgs \
    mavros \
    mavros-msgs \
    rospy \
    sensor-msgs \
    tf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/JdeRobot/drones-release/archive/release/kinetic/drone_wrapper/1.0.1-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "ae8093ed478b99943a12fd3e2edadf6c"
SRC_URI[sha256sum] = "82697ffd8540b432470f10e7ce9a6b622f49a5a7f03af57c9e9ca746bdd7d583"
S = "${WORKDIR}/drones-release-release-kinetic-drone_wrapper-1.0.1-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('jderobot-drones', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('jderobot-drones', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/jderobot-drones/jderobot-drones_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/jderobot-drones/jderobot-drones-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/jderobot-drones/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/jderobot-drones/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

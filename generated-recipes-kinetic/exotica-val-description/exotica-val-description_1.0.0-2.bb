# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "val_description version including our updated meshes for unit testing and visualisation. Based on the OpenHumanoids fork of the val_description package by NASA JSC. The most current version of the original package can be found at http://gitlab.com/nasa-jsc-robotics/val_description"
AUTHOR = "Wolfgang Merkt <wolfgang.merkt@ed.ac.uk>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "NASA-1.3"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=66432e857bf21180c0bbef7cde4f8a21"

ROS_CN = "exotica_val_description"
ROS_BPN = "exotica_val_description"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = ""

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/wxmerkt/exotica_val_description-release/archive/release/kinetic/exotica_val_description/1.0.0-2.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "d3a051e2fc7fb364b211363533c2974c"
SRC_URI[sha256sum] = "79481b6ebf60ec933867e72d9ffab5f1f2e8e347d5971b309b694e3c13d601e9"
S = "${WORKDIR}/exotica_val_description-release-release-kinetic-exotica_val_description-1.0.0-2"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('exotica-val-description', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('exotica-val-description', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/exotica-val-description/exotica-val-description_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/exotica-val-description/exotica-val-description-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/exotica-val-description/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/exotica-val-description/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

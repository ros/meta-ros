# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Orocos component library     This package contains standard components for the Orocos Toolchain"
AUTHOR = "Orocos Developers <orocos-dev@lists.mech.kuleuven.be>"
ROS_AUTHOR = "OCL Development Team"
HOMEPAGE = "http://www.orocos.org/ocl"
SECTION = "devel"
LICENSE = "LGPL-2"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=1da2c67885e8152ec740f5df02cc3f51"

ROS_CN = "ocl"
ROS_BPN = "ocl"

ROS_BUILD_DEPENDS = " \
    libncurses-dev \
    libreadline-dev \
    log4cpp \
    lua-dev \
    netcdf \
    rtt \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
    cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    catkin \
    libncurses-dev \
    libreadline-dev \
    log4cpp \
    lua-dev \
    netcdf \
    rtt \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    catkin \
    libncurses-dev \
    libreadline-dev \
    log4cpp \
    lua-dev \
    netcdf \
    rtt \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/orocos-gbp/ocl-release/archive/release/kinetic/ocl/2.9.2-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "a0ec8723ffbe5556a84ee824514ea09a"
SRC_URI[sha256sum] = "0dd28beff7593cc5e272f442bde9951a50d6b1ebccd9d576b94e91d6154ae53a"
S = "${WORKDIR}/ocl-release-release-kinetic-ocl-2.9.2-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('ocl', d)}"
ROS_BUILD_TYPE = "cmake"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('ocl', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/ocl/ocl_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/ocl/ocl-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/ocl/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/ocl/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

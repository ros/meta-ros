# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The teb_local_planner package implements a plugin     to the base_local_planner of the 2D navigation stack.     The underlying method called Timed Elastic Band locally optimizes     the robot's trajectory with respect to trajectory execution time,     separation from obstacles and compliance with kinodynamic constraints at runtime."
AUTHOR = "Christoph Rösmann <christoph.roesmann@tu-dortmund.de>"
ROS_AUTHOR = "Christoph Rösmann <christoph.roesmann@tu-dortmund.de>"
HOMEPAGE = "http://wiki.ros.org/teb_local_planner"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=16;endline=16;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "teb_local_planner"
ROS_BPN = "teb_local_planner"

ROS_BUILD_DEPENDS = " \
    base-local-planner \
    cmake-modules \
    costmap-2d \
    costmap-converter \
    dynamic-reconfigure \
    geometry-msgs \
    interactive-markers \
    libg2o \
    message-generation \
    nav-core \
    nav-msgs \
    pluginlib \
    roscpp \
    std-msgs \
    tf \
    tf-conversions \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    base-local-planner \
    costmap-2d \
    costmap-converter \
    dynamic-reconfigure \
    geometry-msgs \
    interactive-markers \
    libg2o \
    message-runtime \
    nav-core \
    nav-msgs \
    pluginlib \
    roscpp \
    std-msgs \
    tf \
    tf-conversions \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    base-local-planner \
    costmap-2d \
    costmap-converter \
    dynamic-reconfigure \
    geometry-msgs \
    interactive-markers \
    libg2o \
    message-runtime \
    nav-core \
    nav-msgs \
    pluginlib \
    roscpp \
    std-msgs \
    tf \
    tf-conversions \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/rst-tu-dortmund/teb_local_planner-release/archive/release/kinetic/teb_local_planner/0.6.14-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "dc986f276601da7d4e24a68fc6fb17e9"
SRC_URI[sha256sum] = "281684f9f49ebaea307092c83898bda40652add551b7e7058ad6621952a60b5e"
S = "${WORKDIR}/teb_local_planner-release-release-kinetic-teb_local_planner-0.6.14-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('teb-local-planner', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('teb-local-planner', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/teb-local-planner/teb-local-planner_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/teb-local-planner/teb-local-planner-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/teb-local-planner/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/teb-local-planner/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

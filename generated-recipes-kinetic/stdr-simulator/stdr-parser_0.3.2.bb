# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Provides a library to STDR Simulator, to parse yaml and xml description files."
AUTHOR = "Chris Zalidis <zalidis@gmail.com>"
ROS_AUTHOR = "Manos Tsardoulias, Chris Zalidis, Aris Thallas"
HOMEPAGE = "http://stdr-simulator-ros-pkg.github.io"
SECTION = "devel"
LICENSE = "GPL-3"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=1e7b3bcc2e271699c77c769685058cbe"

ROS_CN = "stdr_simulator"
ROS_BPN = "stdr_parser"

ROS_BUILD_DEPENDS = " \
    cmake-modules \
    libtinyxml \
    roscpp \
    roslib \
    stdr-msgs \
    yaml-cpp \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    libtinyxml \
    roscpp \
    roslib \
    stdr-msgs \
    yaml-cpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    libtinyxml \
    roscpp \
    roslib \
    stdr-msgs \
    yaml-cpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/stdr-simulator-ros-pkg/stdr_simulator-release/archive/release/kinetic/stdr_parser/0.3.2-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "ba778b8795950f369872822b78361ec0"
SRC_URI[sha256sum] = "8f8d08d6f47fb9a326a3a4bfa2d2d2d5cb3c08f25991bf4e169931f5be82bef0"
S = "${WORKDIR}/stdr_simulator-release-release-kinetic-stdr_parser-0.3.2-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('stdr-simulator', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('stdr-simulator', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/stdr-simulator/stdr-simulator_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/stdr-simulator/stdr-simulator-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/stdr-simulator/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/stdr-simulator/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

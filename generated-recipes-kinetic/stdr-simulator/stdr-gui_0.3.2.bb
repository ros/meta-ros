# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "A gui in Qt for visualizing purposes in STDR Simulator."
AUTHOR = "Chris Zalidis <zalidis@gmail.com>"
ROS_AUTHOR = "Manos Tsardoulias"
HOMEPAGE = "http://stdr-simulator-ros-pkg.github.io"
SECTION = "devel"
LICENSE = "GPL-3"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=1e7b3bcc2e271699c77c769685058cbe"

ROS_CN = "stdr_simulator"
ROS_BPN = "stdr_gui"

ROS_BUILD_DEPENDS = " \
    libqt4-dev \
    nav-msgs \
    roscpp \
    roslib \
    sensor-msgs \
    stdr-msgs \
    stdr-parser \
    stdr-robot \
    stdr-server \
    tf \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    nav-msgs \
    roscpp \
    roslib \
    sensor-msgs \
    stdr-msgs \
    stdr-parser \
    stdr-robot \
    stdr-server \
    tf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    libqt4 \
    nav-msgs \
    roscpp \
    roslib \
    sensor-msgs \
    stdr-msgs \
    stdr-parser \
    stdr-robot \
    stdr-server \
    tf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/stdr-simulator-ros-pkg/stdr_simulator-release/archive/release/kinetic/stdr_gui/0.3.2-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "9be6f505a512de15dd4433a79f50fc5c"
SRC_URI[sha256sum] = "444e19a08b4653cf8e4ec8568da5aa6bc4028b93fff48fc81f8544a60ac8a441"
S = "${WORKDIR}/stdr_simulator-release-release-kinetic-stdr_gui-0.3.2-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('stdr-simulator', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('stdr-simulator', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/stdr-simulator/stdr-simulator_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/stdr-simulator/stdr-simulator-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/stdr-simulator/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/stdr-simulator/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Gazebo simulation ROS package for Pheeno system!"
AUTHOR = "Zahi Kakish <zkakish@gmail.com>"
ROS_AUTHOR = "Zahi Kakish"
HOMEPAGE = "https://acslaboratory.github.io"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=15;endline=15;md5=2c00b8d2854109dbebef7818b4dae1e2"

ROS_CN = "pheeno_ros_sim"
ROS_BPN = "pheeno_ros_sim"

ROS_BUILD_DEPENDS = " \
    actionlib \
    actionlib-msgs \
    gazebo-msgs \
    gazebo-plugins \
    gazebo-ros \
    gazebo-ros-control \
    geometry-msgs \
    image-transport \
    message-generation \
    nav-msgs \
    roscpp \
    rospy \
    rviz \
    sensor-msgs \
    std-msgs \
    tf \
    urdf \
    xacro \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    actionlib \
    actionlib-msgs \
    gazebo-msgs \
    gazebo-plugins \
    gazebo-ros \
    gazebo-ros-control \
    geometry-msgs \
    image-transport \
    message-runtime \
    nav-msgs \
    roscpp \
    rospy \
    rviz \
    sensor-msgs \
    std-msgs \
    tf \
    urdf \
    xacro \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    actionlib \
    actionlib-msgs \
    gazebo-msgs \
    gazebo-plugins \
    gazebo-ros \
    gazebo-ros-control \
    geometry-msgs \
    image-transport \
    message-runtime \
    nav-msgs \
    roscpp \
    rospy \
    rviz \
    sensor-msgs \
    std-msgs \
    tf \
    urdf \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ACSLaboratory/pheeno_ros_sim-release/archive/release/kinetic/pheeno_ros_sim/0.1.5-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "333f154ea2e7ec8fba97637449b6c4f9"
SRC_URI[sha256sum] = "b7ad7942e500c94c8d77e9f4ef0d0faa67d80e52fa88f12a5abc037a7f64f524"
S = "${WORKDIR}/pheeno_ros_sim-release-release-kinetic-pheeno_ros_sim-0.1.5-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('pheeno-ros-sim', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('pheeno-ros-sim', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pheeno-ros-sim/pheeno-ros-sim_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pheeno-ros-sim/pheeno-ros-sim-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pheeno-ros-sim/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pheeno-ros-sim/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

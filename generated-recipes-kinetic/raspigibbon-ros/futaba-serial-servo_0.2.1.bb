# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The futaba_serial_servo package"
AUTHOR = "RT Corporation <shop@rt-net.jp>"
ROS_AUTHOR = "Daisuke Sato <tiryoh@gmail.com>"
HOMEPAGE = "https://github.com/rt-net/RaspberryPiGibbon/wiki"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=15;endline=15;md5=2c00b8d2854109dbebef7818b4dae1e2"

ROS_CN = "raspigibbon_ros"
ROS_BPN = "futaba_serial_servo"

ROS_BUILD_DEPENDS = " \
    python-pyserial \
    rospy \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    python-pyserial \
    rospy \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    python-pyserial \
    rospy \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/raspberrypigibbon/raspigibbon_ros-release/archive/release/kinetic/futaba_serial_servo/0.2.1-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "1e55a2644a54b195b1711068c8cdf97c"
SRC_URI[sha256sum] = "9498f9d91ff377a484fd4ba85b80ff1a070a3c21f5cb116f30fa61bda010ca75"
S = "${WORKDIR}/raspigibbon_ros-release-release-kinetic-futaba_serial_servo-0.2.1-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('raspigibbon-ros', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('raspigibbon-ros', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/raspigibbon-ros/raspigibbon-ros_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/raspigibbon-ros/raspigibbon-ros-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/raspigibbon-ros/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/raspigibbon-ros/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

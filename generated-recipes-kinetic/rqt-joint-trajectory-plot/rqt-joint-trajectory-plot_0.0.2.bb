# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The rqt_joint_trajectory_plot package"
AUTHOR = "Tokyo Opensource Robotics Kyokai (TORK) Developer Team <dev@opensource-robotics.tokyo.jp>"
ROS_AUTHOR = "Ryosuke Tajima <ryosuke.tajima@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "rqt_joint_trajectory_plot"
ROS_BPN = "rqt_joint_trajectory_plot"

ROS_BUILD_DEPENDS = " \
    roslaunch \
    roslint \
    rospy \
    rostest \
    rqt-gui \
    rqt-gui-py \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    control-msgs \
    rospy \
    rqt-gui \
    rqt-gui-py \
    trajectory-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    control-msgs \
    rospy \
    rqt-gui \
    rqt-gui-py \
    trajectory-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/tork-a/rqt_joint_trajectory_plot-release/archive/release/kinetic/rqt_joint_trajectory_plot/0.0.2-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "98d3bd40431bd9a3beb11ef12c06f7f9"
SRC_URI[sha256sum] = "d35e000a94e11dcc409b2718f46f86a5581b381c363e70c693edd02e52e61429"
S = "${WORKDIR}/rqt_joint_trajectory_plot-release-release-kinetic-rqt_joint_trajectory_plot-0.0.2-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('rqt-joint-trajectory-plot', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('rqt-joint-trajectory-plot', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rqt-joint-trajectory-plot/rqt-joint-trajectory-plot_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rqt-joint-trajectory-plot/rqt-joint-trajectory-plot-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rqt-joint-trajectory-plot/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rqt-joint-trajectory-plot/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Rover Robotics: ROS package for connecting to SwiftNav Piksi"
AUTHOR = "nick fragale <nick@roverrobotics.com>"
HOMEPAGE = "http://wiki.ros.org/rr_swiftnav_piksi"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "rr_swiftnav_piksi"
ROS_BPN = "rr_swiftnav_piksi"

ROS_BUILD_DEPENDS = " \
    roscpp \
    rospy \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    roscpp \
    rospy \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    roscpp \
    rospy \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/RoverRobotics/rr_swiftnav_piksi-release/archive/release/kinetic/rr_swiftnav_piksi/0.0.1-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "794c24fe7039a3e7f77363204898940d"
SRC_URI[sha256sum] = "1582be8a0ff55c255c8d20245c2a2acadc859aba450b3e72b269dde6984b0a84"
S = "${WORKDIR}/rr_swiftnav_piksi-release-release-kinetic-rr_swiftnav_piksi-0.0.1-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('rr-swiftnav-piksi', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('rr-swiftnav-piksi', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rr-swiftnav-piksi/rr-swiftnav-piksi_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rr-swiftnav-piksi/rr-swiftnav-piksi-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rr-swiftnav-piksi/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rr-swiftnav-piksi/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

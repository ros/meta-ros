# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The hardware interface to an KUKA LBR IIWA Robot"
AUTHOR = "Salvo Virga <salvo.virga@tum.de>"
ROS_AUTHOR = "Salvo Virga <salvo.virga@tum.de>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "iiwa_stack"
ROS_BPN = "iiwa_hw"

ROS_BUILD_DEPENDS = " \
    cmake-modules \
    control-toolbox \
    controller-interface \
    controller-manager \
    hardware-interface \
    iiwa-msgs \
    iiwa-ros \
    joint-limits-interface \
    realtime-tools \
    roscpp \
    tf \
    urdf \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    cmake-modules \
    control-toolbox \
    controller-interface \
    controller-manager \
    hardware-interface \
    iiwa-msgs \
    iiwa-ros \
    joint-limits-interface \
    realtime-tools \
    roscpp \
    tf \
    urdf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    cmake-modules \
    control-toolbox \
    controller-interface \
    controller-manager \
    hardware-interface \
    iiwa-msgs \
    iiwa-ros \
    joint-limits-interface \
    realtime-tools \
    roscpp \
    tf \
    urdf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ipa-rwu/iiwa_stack-release/archive/release/kinetic/iiwa_hw/1.4.1-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "8c2c300bc37444ef9282552fc41a8ea6"
SRC_URI[sha256sum] = "cbe8e6287a261bb47cbff82f27035c6f69dc8fa65ce781cb0af6410e0a91b52f"
S = "${WORKDIR}/iiwa_stack-release-release-kinetic-iiwa_hw-1.4.1-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('iiwa-stack', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('iiwa-stack', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/iiwa-stack/iiwa-stack_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/iiwa-stack/iiwa-stack-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/iiwa-stack/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/iiwa-stack/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

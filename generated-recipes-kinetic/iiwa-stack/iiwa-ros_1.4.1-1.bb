# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The iiwa_ros package"
AUTHOR = "Salvo Virga <salvo.virga@tum.de>"
ROS_AUTHOR = "Salvo Virga <salvo.virga@tum.de>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "iiwa_stack"
ROS_BPN = "iiwa_ros"

ROS_BUILD_DEPENDS = " \
    cmake-modules \
    iiwa-msgs \
    roscpp \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    cmake-modules \
    iiwa-msgs \
    roscpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    cmake-modules \
    iiwa-msgs \
    roscpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ipa-rwu/iiwa_stack-release/archive/release/kinetic/iiwa_ros/1.4.1-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "3c95523dd4073cffcfcd3176a3688c87"
SRC_URI[sha256sum] = "0da94fb4366ddb8fcf9f7e3b8b3a4eeb1b3eb208cea6dd3abc0065be1a5fd0c6"
S = "${WORKDIR}/iiwa_stack-release-release-kinetic-iiwa_ros-1.4.1-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('iiwa-stack', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('iiwa-stack', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/iiwa-stack/iiwa-stack_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/iiwa-stack/iiwa-stack-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/iiwa-stack/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/iiwa-stack/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

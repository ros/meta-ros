# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Utilities and examples for gcloud_speech package."
AUTHOR = "Shengye Wang <shengye@ucsd.edu>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "gcloud_speech"
ROS_BPN = "gcloud_speech_utils"

ROS_BUILD_DEPENDS = " \
    actionlib \
    actionlib-msgs \
    gcloud-speech-msgs \
    gflags \
    glog \
    portaudio19-dev \
    python-pyaudio \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    actionlib \
    actionlib-msgs \
    gcloud-speech-msgs \
    gflags \
    glog \
    portaudio19-dev \
    python-pyaudio \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    actionlib \
    actionlib-msgs \
    gcloud-speech-msgs \
    gflags \
    glog \
    portaudio19-dev \
    python-pyaudio \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/CogRobRelease/gcloud_speech-release/archive/release/kinetic/gcloud_speech_utils/0.0.5-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "e55347819ad83fc6d1264b559a1e8e11"
SRC_URI[sha256sum] = "8355c6e39a67eb1bf6bebc024e7fde0abe69513dd72a067265318072c0ac0200"
S = "${WORKDIR}/gcloud_speech-release-release-kinetic-gcloud_speech_utils-0.0.5-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('gcloud-speech', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('gcloud-speech', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/gcloud-speech/gcloud-speech_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/gcloud-speech/gcloud-speech-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/gcloud-speech/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/gcloud-speech/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

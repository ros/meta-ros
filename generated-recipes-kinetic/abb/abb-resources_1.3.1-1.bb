# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "<p>       Shared configuration data for ABB manipulators.     </p>     <p>       This package contains common urdf / xacro resources used by       ABB related packages.     </p>"
AUTHOR = "Levi Armstrong (Southwest Research Institute) <levi.armstrong@swri.org>"
ROS_AUTHOR = "Levi Armstrong (Southwest Research Institute) <levi.armstrong@swri.org>"
HOMEPAGE = "http://wiki.ros.org/abb_resources"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=16;endline=16;md5=c93e37fc0c6f510db5735eb91dcc1550"

ROS_CN = "abb"
ROS_BPN = "abb_resources"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = ""

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ros-industrial-release/abb-release/archive/release/kinetic/abb_resources/1.3.1-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "0ab138087c417581c091ccdf05d0e169"
SRC_URI[sha256sum] = "025b8ada36f5b3ab8c0c5c8f44c0ad488881d7c6db860be2f1f9eed56aa4b212"
S = "${WORKDIR}/abb-release-release-kinetic-abb_resources-1.3.1-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('abb', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('abb', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/abb/abb_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/abb/abb-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/abb/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/abb/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Add an indication of scale and compass to images."
AUTHOR = "Daniel Snider <danielsnider12@gmail.com>"
ROS_AUTHOR = "Daniel Snider <danielsnider12@gmail.com>"
HOMEPAGE = "http://wiki.ros.org/image_overlay_scale_and_compass"
SECTION = "devel"
LICENSE = "Unlicense"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=c4d59f93d1cbaf4d216df2c1b2ed0dca"

ROS_CN = "image_overlay_scale_and_compass"
ROS_BPN = "image_overlay_scale_and_compass"

ROS_BUILD_DEPENDS = " \
    cv-bridge \
    rospy \
    sensor-msgs \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    click \
    cv-bridge \
    opencv \
    python-numpy \
    rospy \
    sensor-msgs \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    click \
    cv-bridge \
    opencv \
    python-numpy \
    rospy \
    sensor-msgs \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/danielsnider/image_overlay_scale_and_compass-release/archive/release/kinetic/image_overlay_scale_and_compass/0.2.1-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "754cb01c523fbde2cc9f32e388ee63ec"
SRC_URI[sha256sum] = "6cce50c81ea583c78c9e05846e1323493c382b6e367ffe78fd392c27be6f6d68"
S = "${WORKDIR}/image_overlay_scale_and_compass-release-release-kinetic-image_overlay_scale_and_compass-0.2.1-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('image-overlay-scale-and-compass', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('image-overlay-scale-and-compass', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/image-overlay-scale-and-compass/image-overlay-scale-and-compass_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/image-overlay-scale-and-compass/image-overlay-scale-and-compass-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/image-overlay-scale-and-compass/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/image-overlay-scale-and-compass/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Launch files for freenect_camera to produce rectified, registered     or disparity images.  Also produce point clouds and registered     point clouds.  Based on the openni_launch package."
AUTHOR = "Jack O'Quin <jack.oquin@gmail.com>"
ROS_AUTHOR = "Patrick Mihelich (original openni_launch package)"
HOMEPAGE = "http://ros.org/wiki/freenect_launch"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "freenect_stack"
ROS_BPN = "freenect_launch"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    freenect-camera \
    image-proc \
    nodelet \
    rgbd-launch \
    tf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    freenect-camera \
    image-proc \
    nodelet \
    rgbd-launch \
    tf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ros-drivers-gbp/freenect_stack-release/archive/release/kinetic/freenect_launch/0.4.2-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "b92165a6e1b5abbc884de57284986c0e"
SRC_URI[sha256sum] = "c066e806f953b5f3e37aac19086bb8316b20bcf58437d7df63be5562589d669a"
S = "${WORKDIR}/freenect_stack-release-release-kinetic-freenect_launch-0.4.2-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('freenect-stack', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('freenect-stack', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/freenect-stack/freenect-stack_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/freenect-stack/freenect-stack-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/freenect-stack/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/freenect-stack/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

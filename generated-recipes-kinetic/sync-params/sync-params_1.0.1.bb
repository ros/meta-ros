# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Synchronises parameters across multiple masters."
AUTHOR = "Nick Sullivan <nick.dave.sullivan@gmail.com>"
ROS_AUTHOR = "Nick Sullivan <nick.dave.sullivan@gmail.com>"
HOMEPAGE = "https://github.com/NicksSimulationsROS/sync_params"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "sync_params"
ROS_BPN = "sync_params"

ROS_BUILD_DEPENDS = " \
    master-discovery-fkie \
    master-sync-fkie \
    message-generation \
    message-runtime \
    roscpp \
    roslaunch \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    master-discovery-fkie \
    master-sync-fkie \
    message-generation \
    message-runtime \
    roscpp \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    master-discovery-fkie \
    master-sync-fkie \
    message-generation \
    message-runtime \
    roscpp \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/NicksSimulationsROS/sync_params-release/archive/release/kinetic/sync_params/1.0.1-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "4bc0291f846b262b79c1d11f95525ec7"
SRC_URI[sha256sum] = "489e901d3c30a154c755e7b88d86d05e0b5c9aecf2603a435af26f8f6285f60b"
S = "${WORKDIR}/sync_params-release-release-kinetic-sync_params-1.0.1-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('sync-params', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('sync-params', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/sync-params/sync-params_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/sync-params/sync-params-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/sync-params/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/sync-params/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

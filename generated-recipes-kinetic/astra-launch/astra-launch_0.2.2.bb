# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Drivers for Orbbec Astra Devices."
AUTHOR = "Tim Liu <liuhua@orbbec.com>"
ROS_AUTHOR = "Tim Liu <liuhua@orbbec.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=6;endline=6;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "astra_launch"
ROS_BPN = "astra_launch"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    astra-camera \
    depth-image-proc \
    image-proc \
    nodelet \
    rgbd-launch \
    tf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    astra-camera \
    depth-image-proc \
    image-proc \
    nodelet \
    rgbd-launch \
    tf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ros-drivers-gbp/astra_launch-release/archive/release/kinetic/astra_launch/0.2.2-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "5bf01b4f8b75f187f426ae48dba6f116"
SRC_URI[sha256sum] = "fb24af5599e03378f10f1a7e502ac5a18c0777947376ebf54b8460e92095aa40"
S = "${WORKDIR}/astra_launch-release-release-kinetic-astra_launch-0.2.2-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('astra-launch', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('astra-launch', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/astra-launch/astra-launch_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/astra-launch/astra-launch-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/astra-launch/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/astra-launch/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "A fast and flexible implementation of Rigid Body Dynamics algorithms and their analytical derivatives."
AUTHOR = "Justin Carpentier <justin.carpentier@inria.fr>"
HOMEPAGE = "https://github.com/stack-of-tasks/pinocchio"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "pinocchio"
ROS_BPN = "pinocchio"

ROS_BUILD_DEPENDS = " \
    boost \
    doxygen \
    eigenpy \
    git \
    libeigen \
    python \
    python-numpy \
    urdfdom \
"

ROS_BUILDTOOL_DEPENDS = " \
    cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    boost \
    eigenpy \
    libeigen \
    python \
    python-numpy \
    urdfdom \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    boost \
    eigenpy \
    libeigen \
    python \
    python-numpy \
    urdfdom \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ipab-slmc/pinocchio_catkin-release/archive/release/kinetic/pinocchio/2.1.11-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "b3bcb88991a7e1da03d806925b212608"
SRC_URI[sha256sum] = "6d97900a4557556662d2986cb44df838045f03796821a9a14e4a01aac35d8740"
S = "${WORKDIR}/pinocchio_catkin-release-release-kinetic-pinocchio-2.1.11-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('pinocchio', d)}"
ROS_BUILD_TYPE = "cmake"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('pinocchio', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pinocchio/pinocchio_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pinocchio/pinocchio-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pinocchio/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pinocchio/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

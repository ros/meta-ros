# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "This package contains the KDL RTT bindings"
AUTHOR = "Orocos Developers <orocos-dev@lists.mech.kuleuven.be>"
ROS_AUTHOR = "Steven Bellens"
HOMEPAGE = "http://ros.org/wiki/kdl_typekit"
SECTION = "devel"
LICENSE = "LGPL-2"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=420fa5ed95759f902c21c406afe80a37"

ROS_CN = "rtt_geometry"
ROS_BPN = "kdl_typekit"

ROS_BUILD_DEPENDS = " \
    ocl \
    orocos-kdl \
    rtt \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    ocl \
    orocos-kdl \
    rtt \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ocl \
    orocos-kdl \
    rtt \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/orocos-gbp/rtt_geometry-release/archive/release/kinetic/kdl_typekit/2.9.3-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "bf3ee8c553ee3d402d0d851eb4091952"
SRC_URI[sha256sum] = "598e4216da766c6080ba91ddd511ff371f27f5e1ad8fb1642469571ec50ace6f"
S = "${WORKDIR}/rtt_geometry-release-release-kinetic-kdl_typekit-2.9.3-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('rtt-geometry', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('rtt-geometry', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rtt-geometry/rtt-geometry_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rtt-geometry/rtt-geometry-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rtt-geometry/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rtt-geometry/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

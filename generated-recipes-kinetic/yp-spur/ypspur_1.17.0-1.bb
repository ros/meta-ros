# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "YP-Spur is a mobile robot motion control software with coordinate frame based commands."
AUTHOR = "Atsushi Watanabe <atsushi.w@ieee.org>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "yp-spur"
ROS_BPN = "ypspur"

ROS_BUILD_DEPENDS = " \
    libreadline-dev \
"

ROS_BUILDTOOL_DEPENDS = " \
    cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    catkin \
    libedit \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/openspur/yp-spur-release/archive/release/kinetic/ypspur/1.17.0-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "e9c17e77a2fceb4cb0656ca70292a045"
SRC_URI[sha256sum] = "4a39d21cfd4b58e3cae0b8e1b76483e22e411a67dbe7f5d63a9719b87784e17c"
S = "${WORKDIR}/yp-spur-release-release-kinetic-ypspur-1.17.0-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('yp-spur', d)}"
ROS_BUILD_TYPE = "cmake"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('yp-spur', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/yp-spur/yp-spur_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/yp-spur/yp-spur-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/yp-spur/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/yp-spur/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

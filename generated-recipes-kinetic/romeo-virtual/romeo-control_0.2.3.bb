# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Control for Aldebaran's ROMEO robot"
AUTHOR = "Ha Dang <hris2003@gmail.com>"
ROS_AUTHOR = "Konstantinos Chatzilygeroudis <costashatz@gmail.com>"
HOMEPAGE = "https://github.com/ros-aldebaran/romeo_virtual"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=28;endline=28;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "romeo_virtual"
ROS_BPN = "romeo_control"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    robot-state-publisher \
    ros-control \
    ros-controllers \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    robot-state-publisher \
    ros-control \
    ros-controllers \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ros-aldebaran/romeo_virtual-release/archive/release/kinetic/romeo_control/0.2.3-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "ef88cfed88cec5a04f322a8ca79dc7fc"
SRC_URI[sha256sum] = "848e63185fa4e2a33d2dfc121418759f40ab710d81b6bb804cc92fcbc0dbb5d4"
S = "${WORKDIR}/romeo_virtual-release-release-kinetic-romeo_control-0.2.3-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('romeo-virtual', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('romeo-virtual', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/romeo-virtual/romeo-virtual_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/romeo-virtual/romeo-virtual-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/romeo-virtual/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/romeo-virtual/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

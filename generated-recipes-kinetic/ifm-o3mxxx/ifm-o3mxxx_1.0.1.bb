# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The ifm_o3mxxx package"
AUTHOR = "Antti Kolu <antti.kolu@tut.fi>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=2c00b8d2854109dbebef7818b4dae1e2"

ROS_CN = "ifm_o3mxxx"
ROS_BPN = "ifm_o3mxxx"

ROS_BUILD_DEPENDS = " \
    geometry-msgs \
    message-generation \
    pcl-ros \
    roscpp \
    sensor-msgs \
    std-msgs \
    tf \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    geometry-msgs \
    message-runtime \
    pcl-ros \
    roscpp \
    sensor-msgs \
    std-msgs \
    tf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    geometry-msgs \
    message-runtime \
    pcl-ros \
    roscpp \
    sensor-msgs \
    std-msgs \
    tf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/takiaine/ifm_o3mxxx-release/archive/release/kinetic/ifm_o3mxxx/1.0.1-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "001101f7562bcf045e6c4cb03397ff9a"
SRC_URI[sha256sum] = "1c4b8423548da9b6e19cfdd85a7d4451313efb7c1cc1471b810337042b6509c7"
S = "${WORKDIR}/ifm_o3mxxx-release-release-kinetic-ifm_o3mxxx-1.0.1-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('ifm-o3mxxx', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('ifm-o3mxxx', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/ifm-o3mxxx/ifm-o3mxxx_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/ifm-o3mxxx/ifm-o3mxxx-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/ifm-o3mxxx/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/ifm-o3mxxx/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

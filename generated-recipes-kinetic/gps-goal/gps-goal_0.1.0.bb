# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Set a ROS navigation goal using latitude and longitude."
AUTHOR = "Daniel Snider <danielsnider12@gmail.com>"
ROS_AUTHOR = "Daniel Snider <danielsnider12@gmail.com>"
HOMEPAGE = "http://wiki.ros.org/gps_goal"
SECTION = "devel"
LICENSE = "Unlicense"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=c4d59f93d1cbaf4d216df2c1b2ed0dca"

ROS_CN = "gps_goal"
ROS_BPN = "gps_goal"

ROS_BUILD_DEPENDS = " \
    actionlib \
    actionlib-msgs \
    geometry-msgs \
    move-base-msgs \
    rospy \
    sensor-msgs \
    tf \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    actionlib \
    actionlib-msgs \
    click \
    geometry-msgs \
    move-base-msgs \
    python-geographiclib \
    rospy \
    sensor-msgs \
    tf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    actionlib \
    actionlib-msgs \
    click \
    geometry-msgs \
    move-base-msgs \
    python-geographiclib \
    rospy \
    sensor-msgs \
    tf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/danielsnider/gps_goal-release/archive/release/kinetic/gps_goal/0.1.0-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "1971f14195dfaf60901cf416c749d44a"
SRC_URI[sha256sum] = "d576cf5a55de148be6b5c7c65e34904f2ecbaafda7cd42b04627eb403ae24cb3"
S = "${WORKDIR}/gps_goal-release-release-kinetic-gps_goal-0.1.0-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('gps-goal', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('gps-goal', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/gps-goal/gps-goal_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/gps-goal/gps-goal-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/gps-goal/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/gps-goal/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Filters the robot's body out of point clouds."
AUTHOR = "Devon Ash <dash@clearpathrobotics.com>"
ROS_AUTHOR = "Eitan Marder-Eppstein"
HOMEPAGE = "http://ros.org/wiki/robot_self_filter"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "robot_self_filter"
ROS_BPN = "robot_self_filter"

ROS_BUILD_DEPENDS = " \
    assimp \
    bullet \
    filters \
    pcl-ros \
    resource-retriever \
    roscpp \
    sensor-msgs \
    tf \
    urdf \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    assimp \
    bullet \
    filters \
    pcl-ros \
    resource-retriever \
    roscpp \
    sensor-msgs \
    tf \
    urdf \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    assimp \
    bullet \
    filters \
    pcl-ros \
    resource-retriever \
    roscpp \
    sensor-msgs \
    tf \
    urdf \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/pr2-gbp/robot_self_filter-gbp/archive/release/kinetic/robot_self_filter/0.1.30-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "d5d66576fcbfd55b605c0f05aacc8578"
SRC_URI[sha256sum] = "4e815965799f845bee8d0af7d676c260bfae60ef2a4e4902361d753cefb92c6f"
S = "${WORKDIR}/robot_self_filter-gbp-release-kinetic-robot_self_filter-0.1.30-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('robot-self-filter', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('robot-self-filter', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/robot-self-filter/robot-self-filter_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/robot-self-filter/robot-self-filter-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/robot-self-filter/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/robot-self-filter/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

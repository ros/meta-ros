# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Orocos/RTT component framework"
AUTHOR = "Orocos Developers <orocos-dev@lists.mech.kuleuven.be>"
ROS_AUTHOR = "RTT Developers"
HOMEPAGE = "http://www.orocos.org/rtt"
SECTION = "devel"
LICENSE = "GPL-2"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=7296ddd5afe03edd441a1e2c0822aae6"

ROS_CN = "rtt"
ROS_BPN = "rtt"

ROS_BUILD_DEPENDS = " \
    boost \
    omniorb \
    pkgconfig \
    xpath-perl \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
    cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    boost \
    catkin \
    omniorb \
    pkgconfig \
    xpath-perl \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    boost \
    catkin \
    omniorb \
    pkgconfig \
    xpath-perl \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/orocos-gbp/rtt-release/archive/release/kinetic/rtt/2.9.2-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "caa61b3cd61a7acaf216bdf8cf3b360b"
SRC_URI[sha256sum] = "4a5764f77a2ef8648a0f063e6ecf72ec4fc655764bb5dd617d41a1bb8427ea8d"
S = "${WORKDIR}/rtt-release-release-kinetic-rtt-2.9.2-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('rtt', d)}"
ROS_BUILD_TYPE = "cmake"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('rtt', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rtt/rtt_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rtt/rtt-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rtt/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rtt/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

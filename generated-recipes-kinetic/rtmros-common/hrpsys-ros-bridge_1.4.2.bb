# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "hrpsys_ros_bridge package provides basic functionalities to bind   	<a href="http://wiki.ros.org/hrpsys">hrpsys</a>, a    	<a href="http://openrtm.org/">OpenRTM</a>-based controller, and ROS.<br/>      By using this package, you can write your ROS packages that communicate with your     non-ROS robots that run on hrpsys.   		     For communicating with the robots that run on OpenRTM without hrpsys,   	you can use <a href="http://wiki.ros.org/openrtm_ros_bridge">openrtm_ros_bridge</a>   	package."
AUTHOR = "Kei Okada <k-okada@jsk.t.u-tokyo.ac.jp>"
ROS_AUTHOR = "Kei Okada <k-okada@jsk.t.u-tokyo.ac.jp>"
HOMEPAGE = "http://wiki.ros.org/hrpsys_ros_bridge"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=16;endline=16;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "rtmros_common"
ROS_BPN = "hrpsys_ros_bridge"

ROS_BUILD_DEPENDS = " \
    actionlib \
    angles \
    camera-info-manager \
    collada-urdf \
    control-msgs \
    diagnostic-aggregator \
    diagnostic-msgs \
    dynamic-reconfigure \
    euscollada \
    geometry-msgs \
    git \
    hrpsys \
    hrpsys-tools \
    image-transport \
    message-generation \
    mk \
    nav-msgs \
    net-tools \
    nss-myhostname \
    pkgconfig \
    pr2-msgs \
    procps \
    python-rosdep \
    robot-pose-ekf \
    robot-state-publisher \
    rosbuild \
    roscpp \
    roslang \
    rosnode \
    rostest \
    rqt-gui \
    rqt-gui-py \
    rqt-robot-dashboard \
    rqt-robot-monitor \
    rtmbuild \
    sensor-msgs \
    subversion \
    tf \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    actionlib \
    camera-info-manager \
    collada-urdf \
    control-msgs \
    diagnostic-aggregator \
    diagnostic-msgs \
    dynamic-reconfigure \
    geometry-msgs \
    hrpsys \
    hrpsys-tools \
    image-transport \
    ipython \
    nav-msgs \
    pr2-msgs \
    python-psutil \
    robot-pose-ekf \
    robot-state-publisher \
    roscpp \
    rosnode \
    rostest \
    rqt-gui \
    rqt-gui-py \
    rqt-robot-dashboard \
    rqt-robot-monitor \
    rtmbuild \
    sensor-msgs \
    tf \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    actionlib \
    camera-info-manager \
    collada-urdf \
    control-msgs \
    diagnostic-aggregator \
    diagnostic-msgs \
    dynamic-reconfigure \
    geometry-msgs \
    hrpsys \
    hrpsys-tools \
    image-transport \
    ipython \
    nav-msgs \
    pr2-msgs \
    python-psutil \
    robot-pose-ekf \
    robot-state-publisher \
    roscpp \
    rosnode \
    rostest \
    rqt-gui \
    rqt-gui-py \
    rqt-robot-dashboard \
    rqt-robot-monitor \
    rtmbuild \
    sensor-msgs \
    tf \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/tork-a/rtmros_common-release/archive/release/kinetic/hrpsys_ros_bridge/1.4.2-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "3bad0e6677dc29c36baa18806097d1da"
SRC_URI[sha256sum] = "5fc34e800e09ca71d1e2613d972034ef0507d7b1bd0713aadc46e9bb02660eca"
S = "${WORKDIR}/rtmros_common-release-release-kinetic-hrpsys_ros_bridge-1.4.2-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('rtmros-common', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('rtmros-common', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rtmros-common/rtmros-common_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rtmros-common/rtmros-common-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rtmros-common/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rtmros-common/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

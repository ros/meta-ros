# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Stdr version of turtlebot simulation. Convenient to test 2D-navigation related stuffs"
AUTHOR = "Mehdi Tlili <mehdi.tlili@gmail.com>"
ROS_AUTHOR = "Mehdi Tlili <mehdi.tlili@gmail.com>"
HOMEPAGE = "http://wiki.ros.org/turtlebot_stdr"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "turtlebot_simulator"
ROS_BPN = "turtlebot_stdr"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    navigation \
    stdr-gui \
    stdr-resources \
    stdr-robot \
    stdr-server \
    turtlebot-bringup \
    turtlebot-navigation \
    yocs-velocity-smoother \
    yocs-virtual-sensor \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    navigation \
    stdr-gui \
    stdr-resources \
    stdr-robot \
    stdr-server \
    turtlebot-bringup \
    turtlebot-navigation \
    yocs-velocity-smoother \
    yocs-virtual-sensor \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/turtlebot-release/turtlebot_simulator-release/archive/release/kinetic/turtlebot_stdr/2.2.3-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "6c99f516592522257f15222fa436944e"
SRC_URI[sha256sum] = "e434f3c0a8a9410c54a97390f256e4ac5a58574713d0eecfcf2f968affa4265e"
S = "${WORKDIR}/turtlebot_simulator-release-release-kinetic-turtlebot_stdr-2.2.3-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('turtlebot-simulator', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('turtlebot-simulator', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/turtlebot-simulator/turtlebot-simulator_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/turtlebot-simulator/turtlebot-simulator-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/turtlebot-simulator/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/turtlebot-simulator/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

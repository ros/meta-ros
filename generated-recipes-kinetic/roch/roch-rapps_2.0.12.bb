# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The roch_rapps package for set of 'app manager' apps definition"
AUTHOR = "Carl <wzhang@softrobtech.com>"
ROS_AUTHOR = "Carl <wzhang@softrobtech.com>"
HOMEPAGE = "http://ros.org/wiki/roch_rapps"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "roch"
ROS_BPN = "roch_rapps"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    compressed-image-transport \
    nodelet \
    robot-pose-publisher \
    roch-bringup \
    roch-follower \
    roch-navigation \
    roch-teleop \
    tf \
    topic-tools \
    warehouse-ros \
    world-canvas-server \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    compressed-image-transport \
    nodelet \
    robot-pose-publisher \
    roch-bringup \
    roch-follower \
    roch-navigation \
    roch-teleop \
    tf \
    topic-tools \
    warehouse-ros \
    world-canvas-server \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/SawYerRobotics-release/roch-release/archive/release/kinetic/roch_rapps/2.0.12-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "e6c88a11bbb2417eaa7b0aa76fc4e998"
SRC_URI[sha256sum] = "5294102b8ff61174379dca8f19f31c86e9497f189eff28c47c28c7496c04e90a"
S = "${WORKDIR}/roch-release-release-kinetic-roch_rapps-2.0.12-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('roch', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('roch', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/roch/roch_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/roch/roch-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/roch/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/roch/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Utility functions for displaying and debugging data in Rviz via published markers"
AUTHOR = "Dave Coleman <davetcoleman@gmail.com>"
ROS_AUTHOR = "Dave Coleman <davetcoleman@gmail.com>"
HOMEPAGE = "https://github.com/davetcoleman/rviz_visual_tools"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "rviz_visual_tools"
ROS_BPN = "rviz_visual_tools"

ROS_BUILD_DEPENDS = " \
    eigen-conversions \
    eigen-stl-containers \
    geometry-msgs \
    graph-msgs \
    libqt5x11extras5-dev \
    roscpp \
    roslint \
    rviz \
    sensor-msgs \
    std-msgs \
    tf-conversions \
    trajectory-msgs \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    eigen-conversions \
    eigen-stl-containers \
    geometry-msgs \
    graph-msgs \
    libqt5x11extras5-dev \
    roscpp \
    roslint \
    rviz \
    sensor-msgs \
    std-msgs \
    tf-conversions \
    trajectory-msgs \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    eigen-conversions \
    eigen-stl-containers \
    geometry-msgs \
    graph-msgs \
    libqt5x11extras5-dev \
    roscpp \
    roslint \
    rviz \
    sensor-msgs \
    std-msgs \
    tf-conversions \
    trajectory-msgs \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    rostest \
    rosunit \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/davetcoleman/rviz_visual_tools-release/archive/release/kinetic/rviz_visual_tools/3.6.0-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "ca8cf064c305a66566a9bd628b539554"
SRC_URI[sha256sum] = "c31874ae535654e6ef65b52efae8b86799ffcbe0afadf58e13dc22838dd754b6"
S = "${WORKDIR}/rviz_visual_tools-release-release-kinetic-rviz_visual_tools-3.6.0-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('rviz-visual-tools', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('rviz-visual-tools', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rviz-visual-tools/rviz-visual-tools_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rviz-visual-tools/rviz-visual-tools-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rviz-visual-tools/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rviz-visual-tools/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "A friendly library for parsing HTTP request arguments, with built-in support for popular web frameworks, including Flask, Django, Bottle, Tornado, Pyramid, webapp2, Falcon, and aiohttp."
AUTHOR = "AlexV <asmodehn@gmail.com>"
ROS_AUTHOR = "Steven Loria"
HOMEPAGE = "https://github.com/sloria/webargs"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "webargs"
ROS_BPN = "webargs"

ROS_BUILD_DEPENDS = " \
    catkin-pip \
    marshmallow \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    marshmallow \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    marshmallow \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    python-flask \
    python-mock \
    python-pytest \
    python-tornado \
    python-werkzeug \
    webtest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/asmodehn/webargs-rosrelease/archive/release/kinetic/webargs/1.5.3-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "39ff651bfb12b0aed3dc7a740f31314c"
SRC_URI[sha256sum] = "d452af802ac66a0791c25c678d45386ffc72c91ee70db7ee44ec6dae0768fbbd"
S = "${WORKDIR}/webargs-rosrelease-release-kinetic-webargs-1.5.3-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('webargs', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('webargs', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/webargs/webargs_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/webargs/webargs-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/webargs/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/webargs/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

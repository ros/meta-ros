# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "(Python Distribution) A carefully curated collection of Root Certificates for validating the trustworthiness of SSL certificates while verifying the identity of TLS hosts. http://certifi.io"
AUTHOR = "AlexV <asmodehn@gmail.com>"
HOMEPAGE = "https://github.com/certifi/python-certifi"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "certifi"
ROS_BPN = "certifi"

ROS_BUILD_DEPENDS = " \
    catkin-pip \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = ""

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/asmodehn/certifi-rosrelease/archive/release/kinetic/certifi/2015.11.20-3.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "1f36614e39f8d94b55f9b1b5f67be4d9"
SRC_URI[sha256sum] = "4d532dbb968f6d15afdcbcfd6c0aa92218bdcc09a19fc406b3d582a8068c8d2e"
S = "${WORKDIR}/certifi-rosrelease-release-kinetic-certifi-2015.11.20-3"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('certifi', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('certifi', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/certifi/certifi_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/certifi/certifi-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/certifi/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/certifi/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

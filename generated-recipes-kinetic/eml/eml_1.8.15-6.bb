# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "This is an implementation of the EtherCAT master protocol for the PR2       robot based on the work done at Flanders' Mechatronics Technology Centre."
AUTHOR = "David Feil-Seifer <dave@cse.unr.edu>"
ROS_AUTHOR = "Austin Hendrix"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Binary-Only"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=a99890d7e16071ac30156cdebd292056"

ROS_CN = "eml"
ROS_BPN = "eml"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    catkin \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    catkin \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ros-gbp/eml-release/archive/release/kinetic/eml/1.8.15-6.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "b868daeaa90cf464ddd2a3e0fb22d0bd"
SRC_URI[sha256sum] = "6c5835c00492bb87f6fe4e93e036699da219e2db9cfe25b67a5ccc4a0ddb7bf3"
S = "${WORKDIR}/eml-release-release-kinetic-eml-1.8.15-6"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('eml', d)}"
ROS_BUILD_TYPE = "cmake"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('eml', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/eml/eml_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/eml/eml-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/eml/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/eml/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

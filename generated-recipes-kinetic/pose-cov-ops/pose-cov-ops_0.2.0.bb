# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Library with C++ functions for SE(2/3) pose and 2D/3D point     composition operations with uncertainty"
AUTHOR = "Jose-Luis Blanco-Claraco <jlblanco@ual.es>"
HOMEPAGE = "http://wiki.ros.org/pose_cov_ops"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "pose_cov_ops"
ROS_BPN = "pose_cov_ops"

ROS_BUILD_DEPENDS = " \
    geometry-msgs \
    mrpt \
    mrpt-bridge \
    roscpp \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    geometry-msgs \
    mrpt \
    mrpt-bridge \
    roscpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    geometry-msgs \
    mrpt \
    mrpt-bridge \
    roscpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/mrpt-ros-pkg-release/pose_cov_ops-release/archive/release/kinetic/pose_cov_ops/0.2.0-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "843f4a63fc560e2e41ed44e964c49363"
SRC_URI[sha256sum] = "4663f358f5afe1e1cbb6ff548d898fcf19e6a159bdff02819125d149a5652e27"
S = "${WORKDIR}/pose_cov_ops-release-release-kinetic-pose_cov_ops-0.2.0-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('pose-cov-ops', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('pose-cov-ops', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pose-cov-ops/pose-cov-ops_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pose-cov-ops/pose-cov-ops-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pose-cov-ops/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pose-cov-ops/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

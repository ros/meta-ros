# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Binpicking utils metapackage"
AUTHOR = "Frantisek Durovsky <durovsky987@gmail.com>"
ROS_AUTHOR = "Frantisek Durovsky <frantisek.durovsky@smartroboticsys.eu>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "binpicking_utils"
ROS_BPN = "binpicking_utils"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    bin-pose-emulator \
    bin-pose-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    bin-pose-emulator \
    bin-pose-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/durovsky/binpicking_utils-release/archive/release/kinetic/binpicking_utils/0.1.4-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "23e0ec9628139cb8f951ad07e9919879"
SRC_URI[sha256sum] = "071610a5af5c02f6880d49c4af301c3d7e80557d7b41eaec8742f7d24aa659fe"
S = "${WORKDIR}/binpicking_utils-release-release-kinetic-binpicking_utils-0.1.4-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('binpicking-utils', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('binpicking-utils', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/binpicking-utils/binpicking-utils_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/binpicking-utils/binpicking-utils-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/binpicking-utils/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/binpicking-utils/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

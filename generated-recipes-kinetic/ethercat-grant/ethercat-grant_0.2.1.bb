# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Makes it possible to run the ros_ethercat_loop without using sudo. Forked from pr2-grant"
AUTHOR = "Shadow Robot's software team <software@shadowrobot.com>"
ROS_AUTHOR = "Ugo Cupcic <software@shadowrobot.com>"
HOMEPAGE = "http://www.shadowrobot.com/"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "ethercat_grant"
ROS_BPN = "ethercat_grant"

ROS_BUILD_DEPENDS = " \
    libcap-dev \
    roscpp \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    libcap-dev \
    roscpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    libcap-dev \
    roscpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/shadow-robot/ethercat_grant-release/archive/release/kinetic/ethercat_grant/0.2.1-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "8a098a326dcf3581b727ffe541ba2916"
SRC_URI[sha256sum] = "5ed7a26c971fa3db0886d9661e2172d924b62d9c28244e8b9b9c5a4cdd570b58"
S = "${WORKDIR}/ethercat_grant-release-release-kinetic-ethercat_grant-0.2.1-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('ethercat-grant', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('ethercat-grant', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/ethercat-grant/ethercat-grant_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/ethercat-grant/ethercat-grant-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/ethercat-grant/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/ethercat-grant/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

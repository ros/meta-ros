# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The cis_camera package"
AUTHOR = "Yosuke Yamamoto <yamamoto.yosuke@opensource-robotics.tokyo.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "cis_camera"
ROS_BPN = "cis_camera"

ROS_BUILD_DEPENDS = " \
    camera-info-manager \
    cv-bridge \
    dynamic-reconfigure \
    image-transport \
    libuvc \
    nodelet \
    pcl-ros \
    pluginlib \
    roscpp \
    rostest \
    sensor-msgs \
    tf \
    tf-conversions \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    roscpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    camera-info-manager \
    cv-bridge \
    dynamic-reconfigure \
    image-transport \
    jsk-rviz-plugins \
    libuvc \
    nodelet \
    pcl-ros \
    pluginlib \
    rgbd-launch \
    roscpp \
    rqt-reconfigure \
    rviz \
    sensor-msgs \
    tf \
    tf-conversions \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    roslaunch \
    rostest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/tork-a/cis_camera-release/archive/release/kinetic/cis_camera/0.0.3-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "e930e0b62f86ba416fb9f7b859282fa5"
SRC_URI[sha256sum] = "7f4a3e25d151854da023a7a3615342d5f3b0353d66d40abd77cf03b3f3246691"
S = "${WORKDIR}/cis_camera-release-release-kinetic-cis_camera-0.0.3-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('cis-camera', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('cis-camera', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/cis-camera/cis-camera_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/cis-camera/cis-camera-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/cis-camera/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/cis-camera/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

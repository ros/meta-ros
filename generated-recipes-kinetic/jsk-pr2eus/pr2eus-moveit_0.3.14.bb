# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "pr2eus_moveit"
AUTHOR = "YoheiKakiuchi <youhei@jsk.t.u-tokyo.ac.jp>"
ROS_AUTHOR = "YoheiKakiuchi"
HOMEPAGE = "http://ros.org/wiki/pr2eus_moveit"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "jsk_pr2eus"
ROS_BPN = "pr2eus_moveit"

ROS_BUILD_DEPENDS = " \
    control-msgs \
    moveit-msgs \
    pr2eus \
    roseus \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    control-msgs \
    moveit-msgs \
    pr2eus \
    roseus \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    control-msgs \
    moveit-msgs \
    pr2eus \
    roseus \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    moveit-planners-ompl \
    rostest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/tork-a/jsk_pr2eus-release/archive/release/kinetic/pr2eus_moveit/0.3.14-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "e62631bec9e75466732f30ea4b9353a1"
SRC_URI[sha256sum] = "c6d406d24ab0f12f8f32bb26a1bc680223ef5c5f4fd85bdc0e4765ddd9760d86"
S = "${WORKDIR}/jsk_pr2eus-release-release-kinetic-pr2eus_moveit-0.3.14-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('jsk-pr2eus', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('jsk-pr2eus', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/jsk-pr2eus/jsk-pr2eus_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/jsk-pr2eus/jsk-pr2eus-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/jsk-pr2eus/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/jsk-pr2eus/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

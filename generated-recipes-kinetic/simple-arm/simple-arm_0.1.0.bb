# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Simple velocity controlled arm. Teleoperation software and firmware."
AUTHOR = "Daniel Snider <danielsnider12@gmail.com>"
ROS_AUTHOR = "Daniel Snider <danielsnider12@gmail.com>"
HOMEPAGE = "http://wiki.ros.org/simple_arm"
SECTION = "devel"
LICENSE = "Unlicense"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=c4d59f93d1cbaf4d216df2c1b2ed0dca"

ROS_CN = "simple_arm"
ROS_BPN = "simple_arm"

ROS_BUILD_DEPENDS = " \
    rospy \
    sensor-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    python-numpy \
    rospy \
    sensor-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    python-numpy \
    rospy \
    sensor-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/danielsnider/simple_arm-release/archive/release/kinetic/simple_arm/0.1.0-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "20d81accaf365d19b3db72bb0bab765e"
SRC_URI[sha256sum] = "292ef6205a024c748684021d6e2fed99520dc0e5b10f89170869da1beba418c2"
S = "${WORKDIR}/simple_arm-release-release-kinetic-simple_arm-0.1.0-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('simple-arm', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('simple-arm', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/simple-arm/simple-arm_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/simple-arm/simple-arm-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/simple-arm/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/simple-arm/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

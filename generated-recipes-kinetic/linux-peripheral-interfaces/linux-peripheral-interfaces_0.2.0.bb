# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Simple scripts which help utilise, monitor, interact with computer      hardware abstracted by a linux OS."
AUTHOR = "Jihoon Lee <jihoonlee.in@gmail.com>"
HOMEPAGE = "http://wiki.ros.org/linux_peripheral_interfaces"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "linux_peripheral_interfaces"
ROS_BPN = "linux_peripheral_interfaces"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    laptop-battery-monitor \
    libsensors-monitor \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    laptop-battery-monitor \
    libsensors-monitor \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ros-gbp/linux_peripheral_interfaces-release/archive/release/kinetic/linux_peripheral_interfaces/0.2.0-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "b7f0b03bb32eab83ad1879a57702aff5"
SRC_URI[sha256sum] = "12fea2c1a817a1d9498d81655f98536b8d96515c7909cbcbae5851432d3a68e3"
S = "${WORKDIR}/linux_peripheral_interfaces-release-release-kinetic-linux_peripheral_interfaces-0.2.0-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('linux-peripheral-interfaces', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('linux-peripheral-interfaces', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/linux-peripheral-interfaces/linux-peripheral-interfaces_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/linux-peripheral-interfaces/linux-peripheral-interfaces-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/linux-peripheral-interfaces/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/linux-peripheral-interfaces/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

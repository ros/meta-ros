# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "<p>This stack contains packages for humanoid (biped) navigation,     developed at the <a href="http://hrl.informatik.uni-freiburg.de/">Humanoid Robots Lab</a>     at the Albert-Ludwigs-Universitat in Freiburg, Germany.</p>"
AUTHOR = "Pramuditha Aravinda <aravindadp@gmail.com>"
ROS_AUTHOR = "Armin Hornung"
HOMEPAGE = "http://wiki.ros.org/humanoid_navigation"
SECTION = "devel"
LICENSE = "BSD & GPL-3"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "humanoid_navigation"
ROS_BPN = "humanoid_navigation"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    footstep-planner \
    gridmap-2d \
    humanoid-localization \
    humanoid-planner-2d \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ROBOTIS-GIT-release/humanoid_navigation-release/archive/release/kinetic/humanoid_navigation/0.4.2-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "8141902be97cd4c7f211fb3d7d145e52"
SRC_URI[sha256sum] = "254f9cc21e82934f0f6519b6a374d6c4f96691411a2c92a9afa5364d75024b7f"
S = "${WORKDIR}/humanoid_navigation-release-release-kinetic-humanoid_navigation-0.4.2-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('humanoid-navigation', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('humanoid-navigation', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/humanoid-navigation/humanoid-navigation_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/humanoid-navigation/humanoid-navigation-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/humanoid-navigation/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/humanoid-navigation/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

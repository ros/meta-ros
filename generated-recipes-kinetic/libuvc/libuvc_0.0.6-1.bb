# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "USB Video Class driver library"
AUTHOR = "Ken Tossell <ken@tossell.net>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "libuvc"
ROS_BPN = "libuvc"

ROS_BUILD_DEPENDS = " \
    jpeg \
    libusb1 \
    pkgconfig \
"

ROS_BUILDTOOL_DEPENDS = " \
    cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    catkin \
    jpeg \
    libusb1 \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    catkin \
    jpeg \
    libusb1 \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ktossell/libuvc-release/archive/release/kinetic/libuvc/0.0.6-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "8a39553508e6ee8e96cc3895e7bb9ab4"
SRC_URI[sha256sum] = "1521cdeba14d76a418d756a21b288ec84d191132bd9f4c2b634fd9df70a8b8b3"
S = "${WORKDIR}/libuvc-release-release-kinetic-libuvc-0.0.6-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('libuvc', d)}"
ROS_BUILD_TYPE = "cmake"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('libuvc', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/libuvc/libuvc_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/libuvc/libuvc-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/libuvc/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/libuvc/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

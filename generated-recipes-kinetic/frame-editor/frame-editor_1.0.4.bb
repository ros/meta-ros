# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The frame_editor package"
AUTHOR = "ipa-lth <lorenz.halt@ipa.fraunhofer.de>"
ROS_AUTHOR = "ipa-lth <lorenz.halt@ipa.fraunhofer.de>"
HOMEPAGE = "http://www.ipa.fraunhofer.de/"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=2c00b8d2854109dbebef7818b4dae1e2"

ROS_CN = "frame_editor"
ROS_BPN = "frame_editor"

ROS_BUILD_DEPENDS = " \
    dynamic-reconfigure \
    geometry-msgs \
    interactive-markers \
    message-generation \
    rospy \
    rqt-gui \
    rqt-gui-py \
    std-msgs \
    tf \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    dynamic-reconfigure \
    geometry-msgs \
    interactive-markers \
    message-runtime \
    rospy \
    rqt-gui \
    rqt-gui-py \
    std-msgs \
    tf \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    dynamic-reconfigure \
    geometry-msgs \
    interactive-markers \
    message-runtime \
    rospy \
    rqt-gui \
    rqt-gui-py \
    std-msgs \
    tf \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ipa320/rqt_frame_editor_plugin-release/archive/release/kinetic/frame_editor/1.0.4-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "2c0c43c2034235325101a9fa8109ccf9"
SRC_URI[sha256sum] = "c4dd2fd3a521ea24f14ef5fa08270ddf47b4ae6567bc152985791bd1b8a6596c"
S = "${WORKDIR}/rqt_frame_editor_plugin-release-release-kinetic-frame_editor-1.0.4-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('frame-editor', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('frame-editor', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/frame-editor/frame-editor_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/frame-editor/frame-editor-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/frame-editor/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/frame-editor/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

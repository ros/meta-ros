# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The melfa_robot meta package"
AUTHOR = "Tokyo Opensource Robotics Kyokai (TORK) Developer Team <dev@opensource-robotics.tokyo.jp>"
HOMEPAGE = "http://wiki.ros.org/melfa_robot"
SECTION = "devel"
LICENSE = "Apache-2.0 & CC-BY-SA"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "melfa_robot"
ROS_BPN = "melfa_robot"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    melfa-description \
    melfa-driver \
    rv4fl-moveit-config \
    rv7fl-moveit-config \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/tork-a/melfa_robot-release/archive/release/kinetic/melfa_robot/0.0.4-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "ca15fcd3833ed58b5e52e8af5da0d580"
SRC_URI[sha256sum] = "1efab4205f76db2a0c708c47f7048ec5b04f8e8842ac63efe31fd5e7d7c14138"
S = "${WORKDIR}/melfa_robot-release-release-kinetic-melfa_robot-0.0.4-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('melfa-robot', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('melfa-robot', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/melfa-robot/melfa-robot_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/melfa-robot/melfa-robot-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/melfa-robot/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/melfa-robot/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

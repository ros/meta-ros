# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The OSG Bullet library adapted to UWSim. See https://code.google.com/p/osgbullet"
AUTHOR = "Mario Prats <marioprats@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "LGPL-2"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=46ee8693f40a89a31023e97ae17ecf19"

ROS_CN = "uwsim_osgbullet"
ROS_BPN = "uwsim_osgbullet"

ROS_BUILD_DEPENDS = " \
    boost \
    libopenscenegraph \
    uwsim-bullet \
    uwsim-osgworks \
"

ROS_BUILDTOOL_DEPENDS = " \
    cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    boost \
    catkin \
    libopenscenegraph \
    uwsim-bullet \
    uwsim-osgworks \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    boost \
    catkin \
    libopenscenegraph \
    uwsim-bullet \
    uwsim-osgworks \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/uji-ros-pkg/uwsim_osgbullet-release/archive/release/kinetic/uwsim_osgbullet/3.0.1-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "1602ecde8c0c8f719018e1913c7f59f8"
SRC_URI[sha256sum] = "a3b912aa1c36abd61d916a60ae4fb67596cdb5893de4caa5f2ae2ca93368ea6e"
S = "${WORKDIR}/uwsim_osgbullet-release-release-kinetic-uwsim_osgbullet-3.0.1-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('uwsim-osgbullet', d)}"
ROS_BUILD_TYPE = "cmake"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('uwsim-osgbullet', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/uwsim-osgbullet/uwsim-osgbullet_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/uwsim-osgbullet/uwsim-osgbullet-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/uwsim-osgbullet/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/uwsim-osgbullet/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

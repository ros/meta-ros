# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "SMACHA (short for &quot;State Machine Assembler&quot;, pronounced &quot;smasha&quot;) aims at distilling the task-level simplicity of SMACH into compact YAML-based scripts in the foreground, while retaining all of its power and flexibility in Jinja2-based templates and a custom code generation engine in the background."
AUTHOR = "Barry Ridge <barry.ridge@ijs.si>"
ROS_AUTHOR = "Barry Ridge <barry.ridge@ijs.si>"
HOMEPAGE = "http://ros.org/wiki/smacha"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "smacha"
ROS_BPN = "smacha"

ROS_BUILD_DEPENDS = " \
    python-jinja2 \
    python-ruamel.yaml \
    smach \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    python-jinja2 \
    python-ruamel.yaml \
    smach \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    python-jinja2 \
    python-ruamel.yaml \
    smach \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    python-unittest2 \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ReconCell/smacha-release/archive/release/kinetic/smacha/0.5.0-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "b62569445513f056a6d620adc5f289b2"
SRC_URI[sha256sum] = "01250572e0485a1afb31328c92087e449212c0473d316a113a5a304d82b95300"
S = "${WORKDIR}/smacha-release-release-kinetic-smacha-0.5.0-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('smacha', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('smacha', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/smacha/smacha_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/smacha/smacha-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/smacha/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/smacha/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "A viewer for the SLAM component of roboception based on ROS and PCL"
AUTHOR = "Felix Endres <felix.endres@roboception.de>"
ROS_AUTHOR = "Felix Endres <felix.endres@roboception.de>"
HOMEPAGE = "https://wiki.ros.org/rc_cloud_accumulator"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "rc_cloud_accumulator"
ROS_BPN = "rc_cloud_accumulator"

ROS_BUILD_DEPENDS = " \
    geometry-msgs \
    libvtk-qt \
    nav-msgs \
    pcl \
    pcl-ros \
    roscpp \
    std-srvs \
    tf2 \
    tf2-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    geometry-msgs \
    libvtk-qt \
    nav-msgs \
    pcl \
    pcl-ros \
    roscpp \
    std-srvs \
    tf2 \
    tf2-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    geometry-msgs \
    libvtk-qt \
    nav-msgs \
    pcl \
    pcl-ros \
    roscpp \
    std-srvs \
    tf2 \
    tf2-msgs \
    tf2-ros \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/roboception-gbp/rc_cloud_accumulator-release/archive/release/kinetic/rc_cloud_accumulator/1.0.4-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "548afcd6edf7eced19c61ec88f83eb35"
SRC_URI[sha256sum] = "9f7218122b8d827536e815a96fb251fbc1c84bca566678eb4bea2b3b2bcbeedd"
S = "${WORKDIR}/rc_cloud_accumulator-release-release-kinetic-rc_cloud_accumulator-1.0.4-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('rc-cloud-accumulator', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('rc-cloud-accumulator', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rc-cloud-accumulator/rc-cloud-accumulator_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rc-cloud-accumulator/rc-cloud-accumulator-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rc-cloud-accumulator/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rc-cloud-accumulator/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

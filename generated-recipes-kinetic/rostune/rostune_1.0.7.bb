# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "rostune is a tool that helps ROS developers distribute their nodes in the most effective way. It collects statistics for topics and nodes, such as CPU and network usage."
AUTHOR = "George Stavrinos <gstavrinos@iit.demokritos.gr>"
ROS_AUTHOR = "George Stavrinos <gstavrinos@iit.demokritos.gr>"
HOMEPAGE = "http://wiki.ros.org/rostune"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "rostune"
ROS_BPN = "rostune"

ROS_BUILD_DEPENDS = " \
    message-generation \
    std-msgs \
    topic-tools \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    message-runtime \
    std-msgs \
    topic-tools \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    message-runtime \
    std-msgs \
    topic-tools \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/roboskel/rostune-release/archive/release/kinetic/rostune/1.0.7-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "c2b95e46af2bdeb974fb59c78ee7f866"
SRC_URI[sha256sum] = "534824c7b7e90a2a392ddb2bd82ac53ee867626be2a781a8fe55438afca1a6a7"
S = "${WORKDIR}/rostune-release-release-kinetic-rostune-1.0.7-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('rostune', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('rostune', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rostune/rostune_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rostune/rostune-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rostune/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rostune/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

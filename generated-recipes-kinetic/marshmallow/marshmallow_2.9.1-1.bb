# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "A lightweight library for converting complex objects to and from simple Python datatypes."
AUTHOR = "AlexV <asmodehn@gmail.com>"
ROS_AUTHOR = "Steven Loria"
HOMEPAGE = "https://github.com/marshmallow-code/marshmallow"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "marshmallow"
ROS_BPN = "marshmallow"

ROS_BUILD_DEPENDS = " \
    catkin-pip \
    python-dateutil \
    python-simplejson \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    python-dateutil \
    python-simplejson \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    python-dateutil \
    python-simplejson \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    python-pytest \
    python-tz \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/asmodehn/marshmallow-rosrelease/archive/release/kinetic/marshmallow/2.9.1-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "3ad6daa9bb818c1e4483da90f5910e60"
SRC_URI[sha256sum] = "2f7e9fef89263703fb78c0503becd0f1bd6b3d24f8b6888e4c7248275359153d"
S = "${WORKDIR}/marshmallow-rosrelease-release-kinetic-marshmallow-2.9.1-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('marshmallow', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('marshmallow', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/marshmallow/marshmallow_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/marshmallow/marshmallow-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/marshmallow/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/marshmallow/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

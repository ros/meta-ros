# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "This package provides nodes for calculating the minimal distance to robot links, obstacles and octomap using MoveIt!'s PlanningSceneMonitor"
AUTHOR = "Felix Messmer <fxm@ipa.fhg.de>"
ROS_AUTHOR = "Florian Koehler <koellsch86@googlemail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=80318c4afef111a7690eaf237460856b"

ROS_CN = "cob_manipulation"
ROS_BPN = "cob_obstacle_distance_moveit"

ROS_BUILD_DEPENDS = " \
    boost \
    cob-control-msgs \
    cob-srvs \
    eigen-conversions \
    fcl \
    geometric-shapes \
    geometry-msgs \
    moveit-core \
    moveit-msgs \
    moveit-ros-perception \
    moveit-ros-planning-interface \
    pkgconfig \
    roscpp \
    tf \
    tf-conversions \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    boost \
    cob-control-msgs \
    cob-srvs \
    eigen-conversions \
    fcl \
    geometric-shapes \
    geometry-msgs \
    moveit-core \
    moveit-msgs \
    moveit-ros-perception \
    moveit-ros-planning-interface \
    pkgconfig \
    roscpp \
    tf \
    tf-conversions \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    boost \
    cob-control-msgs \
    cob-srvs \
    eigen-conversions \
    fcl \
    geometric-shapes \
    geometry-msgs \
    moveit-core \
    moveit-msgs \
    moveit-ros-perception \
    moveit-ros-planning-interface \
    pkgconfig \
    roscpp \
    rospy \
    tf \
    tf-conversions \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ipa320/cob_manipulation-release/archive/release/kinetic/cob_obstacle_distance_moveit/0.7.2-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "11668c4fc54a2fefd93d27d9b17c7f57"
SRC_URI[sha256sum] = "3e061b54886f2c8481f05c15b88f35db24ffca3049eb0b22274cde59f9d013f6"
S = "${WORKDIR}/cob_manipulation-release-release-kinetic-cob_obstacle_distance_moveit-0.7.2-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('cob-manipulation', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('cob-manipulation', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/cob-manipulation/cob-manipulation_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/cob-manipulation/cob-manipulation-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/cob-manipulation/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/cob-manipulation/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

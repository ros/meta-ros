# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "<p>       Shared configuration data, 3D models and launch files for Fanuc       manipulators.     </p>     <p>       This package contains configuration data, 3D models and launch files       that are shared between different Fanuc robot support packages       within the ROS-Industrial program.        This package also contains common urdf / xacro resources used by       other Fanuc related packages.     </p>"
AUTHOR = "G.A. vd. Hoorn (TU Delft Robotics Institute) <g.a.vanderhoorn@tudelft.nl>"
ROS_AUTHOR = "G.A. vd. Hoorn (TU Delft Robotics Institute)"
HOMEPAGE = "http://wiki.ros.org/fanuc_resources"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=22;endline=22;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "fanuc"
ROS_BPN = "fanuc_resources"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = ""

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ros-industrial-release/fanuc-release/archive/release/kinetic/fanuc_resources/0.5.0-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "dd84cb8bb82b4910d68cc409903cb40b"
SRC_URI[sha256sum] = "938101a15261636944fd5f35b7784d873f2405d8764980f0fa643b6255783b36"
S = "${WORKDIR}/fanuc-release-release-kinetic-fanuc_resources-0.5.0-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('fanuc', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('fanuc', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/fanuc/fanuc_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/fanuc/fanuc-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/fanuc/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/fanuc/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

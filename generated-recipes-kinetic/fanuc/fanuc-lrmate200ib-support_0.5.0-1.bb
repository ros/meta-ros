# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "<p>       ROS-Industrial support for the Fanuc LR Mate 200iB (and variants).     </p>     <p>       This package contains configuration data, 3D models and launch files       for Fanuc LR Mate 200iB manipulators. This currently includes the base       model and the /3L.     </p>     <p>       Joint limits and maximum joint velocities are based on the information in       the <em>Fanuc LR Mate 200iB-200iB/3L datasheet</em>, dated <em>24-Feb-2003</em>.       All urdfs are based on the default motion and joint velocity limits,       unless noted otherwise (ie: no support for high speed joints,       extended / limited motion ranges or other options).     </p>     <p>       Before using any of the configuration files and / or meshes included       in this package, be sure to check they are correct for the particular       robot model and configuration you intend to use them with.     </p>     <p><b>Contributors</b>:</p>     <p>       This support package has received contributions from: Victor Lamoine.     </p>"
AUTHOR = "G.A. vd. Hoorn (TU Delft Robotics Institute) <g.a.vanderhoorn@tudelft.nl>"
ROS_AUTHOR = "G.A. vd. Hoorn (TU Delft Robotics Institute)"
HOMEPAGE = "http://ros.org/wiki/fanuc_lrmate200ib_support"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=34;endline=34;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "fanuc"
ROS_BPN = "fanuc_lrmate200ib_support"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    fanuc-driver \
    fanuc-resources \
    joint-state-publisher \
    robot-state-publisher \
    rviz \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    roslaunch \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ros-industrial-release/fanuc-release/archive/release/kinetic/fanuc_lrmate200ib_support/0.5.0-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "89951202cc9c565f17dedd1fda32f577"
SRC_URI[sha256sum] = "ce3cb97cdffae9b04b67b48845b8ebf84184140252d35495b25bd63c38fe1d1c"
S = "${WORKDIR}/fanuc-release-release-kinetic-fanuc_lrmate200ib_support-0.5.0-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('fanuc', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('fanuc', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/fanuc/fanuc_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/fanuc/fanuc-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/fanuc/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/fanuc/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "<p>      ROS-Industrial nodes for interfacing with Fanuc robot controllers.    </p>    <p>      This package is part of the ROS-Industrial program and contains nodes      for interfacing with Fanuc industrial robot controllers that support      the KAREL programming environment.    </p>"
AUTHOR = "G.A. vd. Hoorn (TU Delft Robotics Institute) <g.a.vanderhoorn@tudelft.nl>"
ROS_AUTHOR = "G.A. vd. Hoorn (TU Delft Robotics Institute)"
HOMEPAGE = "http://wiki.ros.org/fanuc_driver"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=18;endline=18;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "fanuc"
ROS_BPN = "fanuc_driver"

ROS_BUILD_DEPENDS = " \
    industrial-robot-client \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    industrial-robot-client \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    industrial-robot-client \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    roslaunch \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ros-industrial-release/fanuc-release/archive/release/kinetic/fanuc_driver/0.5.0-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "01ae66721a515e3fe21f6f3ebfb3b6e4"
SRC_URI[sha256sum] = "b4cea0375f81ac549311713f0ceb785730f485c9cbacb2592f70c06bffd9be5d"
S = "${WORKDIR}/fanuc-release-release-kinetic-fanuc_driver-0.5.0-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('fanuc', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('fanuc', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/fanuc/fanuc_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/fanuc/fanuc-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/fanuc/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/fanuc/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

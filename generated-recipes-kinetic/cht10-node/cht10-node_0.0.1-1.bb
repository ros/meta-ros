# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The dumpbot_serial_func package for getting data of dumpbot from MCU"
AUTHOR = "Carl <1271087623@qq.comd>"
ROS_AUTHOR = "Carl <1271087623@qq.comd>"
HOMEPAGE = "http://ros.org/wiki/cht10_node"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "cht10_node"
ROS_BPN = "cht10_node"

ROS_BUILD_DEPENDS = " \
    ecl-threads \
    nodelet \
    pluginlib \
    roscpp \
    sensor-msgs \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    ecl-threads \
    nodelet \
    pluginlib \
    roscpp \
    sensor-msgs \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ecl-threads \
    nodelet \
    pluginlib \
    roscpp \
    sensor-msgs \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/Playfish/cht10_node_release/archive/release/kinetic/cht10_node/0.0.1-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "45bc52fdc4244fbe7d061b6951d449f7"
SRC_URI[sha256sum] = "74603b7a6428bb76f03f8ab757a6410c02aaca14c1a5e493d0dd10c83c59ddec"
S = "${WORKDIR}/cht10_node_release-release-kinetic-cht10_node-0.0.1-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('cht10-node', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('cht10-node', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/cht10-node/cht10-node_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/cht10-node/cht10-node-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/cht10-node/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/cht10-node/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Package which implements capabilities, including code to parse capability interface specs, to parse capability provider specs, and implement the capability server."
AUTHOR = "William Woodall <william@osrfoundation.org>"
ROS_AUTHOR = "William Woodall <william@osrfoundation.org>"
HOMEPAGE = "http://wiki.ros.org/capabilities"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "capabilities"
ROS_BPN = "capabilities"

ROS_BUILD_DEPENDS = " \
    message-generation \
    roslaunch \
    rospy \
    rostest \
    std-msgs \
    std-srvs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    bondpy \
    message-runtime \
    nodelet \
    python-pyyaml \
    roslaunch \
    rospy \
    std-msgs \
    std-srvs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    bondpy \
    message-runtime \
    nodelet \
    python-pyyaml \
    roslaunch \
    rospy \
    std-msgs \
    std-srvs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    geometry-msgs \
    python-coverage-native \
    python-mock \
    python-pep8 \
    rosservice \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ros-gbp/capabilities-release/archive/release/kinetic/capabilities/0.2.0-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "b570bfec092cbd71862b5b1c399d688c"
SRC_URI[sha256sum] = "0e077da92875d7bec29456cecf7efcd16f42e14bfb8e28ced30e86c6d9d5ff9c"
S = "${WORKDIR}/capabilities-release-release-kinetic-capabilities-0.2.0-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('capabilities', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('capabilities', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/capabilities/capabilities_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/capabilities/capabilities-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/capabilities/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/capabilities/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

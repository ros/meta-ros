# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Messages and services for humanoid robots"
AUTHOR = "Armin Hornung <HornungA@informatik.uni-freiburg.de>"
HOMEPAGE = "http://www.ros.org/wiki/humanoid_msgs"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "humanoid_msgs"
ROS_BPN = "humanoid_msgs"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = ""

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ros-gbp/humanoid_msgs-release/archive/release/kinetic/humanoid_msgs/0.3.0-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "65185b1351cb075d15a748130674a5f3"
SRC_URI[sha256sum] = "2c3e9b61c10aef451b3a82b45d659d95acfe526c3456be2849716a7c5ff151a3"
S = "${WORKDIR}/humanoid_msgs-release-release-kinetic-humanoid_msgs-0.3.0-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('humanoid-msgs', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('humanoid-msgs', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/humanoid-msgs/humanoid-msgs_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/humanoid-msgs/humanoid-msgs-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/humanoid-msgs/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/humanoid-msgs/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

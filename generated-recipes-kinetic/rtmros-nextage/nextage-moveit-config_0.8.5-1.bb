# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "An automatically generated package with all the configuration and launch files for using the NextageOpen with the MoveIt Motion Planning Framework."
AUTHOR = "Kei Okada <k-okada@jsk.t.u-tokyo.ac.jp>"
ROS_AUTHOR = "Kei Okada"
HOMEPAGE = "http://ros.org/wiki/nextage_moveit_config"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "rtmros_nextage"
ROS_BPN = "nextage_moveit_config"

ROS_BUILD_DEPENDS = " \
    hironx-moveit-config \
    nextage-ros-bridge \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    hironx-moveit-config \
    moveit-planners \
    moveit-ros \
    moveit-ros-move-group \
    moveit-ros-planning-interface \
    moveit-ros-visualization \
    moveit-simple-controller-manager \
    nextage-ros-bridge \
    trac-ik-kinematics-plugin \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    hironx-moveit-config \
    moveit-planners \
    moveit-ros \
    moveit-ros-move-group \
    moveit-ros-planning-interface \
    moveit-ros-visualization \
    moveit-simple-controller-manager \
    nextage-ros-bridge \
    trac-ik-kinematics-plugin \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    joint-state-publisher \
    robot-state-publisher \
    rostest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/tork-a/rtmros_nextage-release/archive/release/kinetic/nextage_moveit_config/0.8.5-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "32faae8c2f60d45eee716f9224b00e38"
SRC_URI[sha256sum] = "d0368cb6f985bc16978709d4dd315e286b645d21894ee578a417df16fa62e1f1"
S = "${WORKDIR}/rtmros_nextage-release-release-kinetic-nextage_moveit_config-0.8.5-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('rtmros-nextage', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('rtmros-nextage', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rtmros-nextage/rtmros-nextage_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rtmros-nextage/rtmros-nextage-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rtmros-nextage/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/rtmros-nextage/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

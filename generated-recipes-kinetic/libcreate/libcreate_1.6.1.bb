# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "C++ library for interfacing with iRobot's Create 1 and Create 2"
AUTHOR = "Jacob Perron <jperron@sfu.ca>"
ROS_AUTHOR = "Jacob Perron <jperron@sfu.ca>"
HOMEPAGE = "http://wiki.ros.org/libcreate"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "libcreate"
ROS_BPN = "libcreate"

ROS_BUILD_DEPENDS = " \
    boost \
"

ROS_BUILDTOOL_DEPENDS = " \
    cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    boost \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    boost \
    catkin \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    gtest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/AutonomyLab/libcreate-release/archive/release/kinetic/libcreate/1.6.1-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "c22b89c9aa1fbf27a5f7411daf9ae768"
SRC_URI[sha256sum] = "4c749124a45a335b371fcb36d61c58c4191671efedc8a8b26bdb768a77f52b14"
S = "${WORKDIR}/libcreate-release-release-kinetic-libcreate-1.6.1-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('libcreate', d)}"
ROS_BUILD_TYPE = "cmake"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('libcreate', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/libcreate/libcreate_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/libcreate/libcreate-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/libcreate/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/libcreate/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "ROS Node that convert IMU data to a Twist for manual robot drive."
AUTHOR = "Easymov Robotics <dev@easymov.fr>"
ROS_AUTHOR = "Gérald Lelong <gerald.lelong@easymov.fr>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=15;endline=15;md5=2c00b8d2854109dbebef7818b4dae1e2"

ROS_CN = "twistimu"
ROS_BPN = "twistimu"

ROS_BUILD_DEPENDS = " \
    dynamic-reconfigure \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    dynamic-reconfigure \
    geometry-msgs \
    rospy \
    sensor-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    dynamic-reconfigure \
    geometry-msgs \
    rospy \
    sensor-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/easymov/twistimu-release/archive/release/kinetic/twistimu/1.0.0-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "1c31bd07a4e51b53191191f729f44cb7"
SRC_URI[sha256sum] = "fb44eeb670d3a4f34cb98abeb57833217a69197cc3691a90825713a0e9171995"
S = "${WORKDIR}/twistimu-release-release-kinetic-twistimu-1.0.0-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('twistimu', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('twistimu', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/twistimu/twistimu_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/twistimu/twistimu-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/twistimu/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/twistimu/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

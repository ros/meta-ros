# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Conversions between ros and sophus."
AUTHOR = "Daniel Stonier <d.stonier@gmail.com>"
ROS_AUTHOR = "Daniel Stonier"
HOMEPAGE = "https://github.com/stonier/sophus_ros_toolkit"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "sophus_ros_toolkit"
ROS_BPN = "sophus_ros_conversions"

ROS_BUILD_DEPENDS = " \
    cmake-modules \
    ecl-build \
    geometry-msgs \
    sophus \
    tf \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    cmake-modules \
    ecl-build \
    geometry-msgs \
    sophus \
    tf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    cmake-modules \
    ecl-build \
    geometry-msgs \
    sophus \
    tf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/yujinrobot-release/sophus_ros_toolkit-release/archive/release/kinetic/sophus_ros_conversions/0.1.3-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "5a425a9d1a886ac834bfde4467c29072"
SRC_URI[sha256sum] = "e1cfba0989700bb4b96f67c8e60c3d7c7b69f51aca0b8a8457a287436e8b9d65"
S = "${WORKDIR}/sophus_ros_toolkit-release-release-kinetic-sophus_ros_conversions-0.1.3-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('sophus-ros-toolkit', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('sophus-ros-toolkit', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/sophus-ros-toolkit/sophus-ros-toolkit_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/sophus-ros-toolkit/sophus-ros-toolkit-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/sophus-ros-toolkit/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/sophus-ros-toolkit/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "This package holds navigation-specific sensor configuration options and launch files for the PR2."
AUTHOR = "David Feil-Seifer <dave@cse.unr.edu>"
ROS_AUTHOR = "Eitan Marder-Eppstein"
HOMEPAGE = "http://ros.org/wiki/pr2_navigation_perception"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "pr2_navigation"
ROS_BPN = "pr2_navigation_perception"

ROS_BUILD_DEPENDS = " \
    dynamic-reconfigure \
    filters \
    geometry-msgs \
    laser-filters \
    laser-geometry \
    laser-tilt-controller-filter \
    message-filters \
    pcl-ros \
    pr2-machine \
    pr2-navigation-self-filter \
    roscpp \
    semantic-point-annotator \
    sensor-msgs \
    tf \
    topic-tools \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    dynamic-reconfigure \
    filters \
    geometry-msgs \
    laser-filters \
    laser-geometry \
    laser-tilt-controller-filter \
    message-filters \
    pcl-ros \
    pr2-machine \
    pr2-navigation-self-filter \
    roscpp \
    semantic-point-annotator \
    sensor-msgs \
    tf \
    topic-tools \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    dynamic-reconfigure \
    filters \
    geometry-msgs \
    laser-filters \
    laser-geometry \
    laser-tilt-controller-filter \
    message-filters \
    pcl-ros \
    pr2-machine \
    pr2-navigation-self-filter \
    roscpp \
    semantic-point-annotator \
    sensor-msgs \
    tf \
    topic-tools \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/pr2-gbp/pr2_navigation-release/archive/release/kinetic/pr2_navigation_perception/0.1.28-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "2147609256b44598e501a9368dcfcadf"
SRC_URI[sha256sum] = "9e08b777d996bbd1e8318fcb1185717840355402b1745fcb5e7a95496a8fe66d"
S = "${WORKDIR}/pr2_navigation-release-release-kinetic-pr2_navigation_perception-0.1.28-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('pr2-navigation', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('pr2-navigation', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pr2-navigation/pr2-navigation_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pr2-navigation/pr2-navigation-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pr2-navigation/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pr2-navigation/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The nmea_gps_plugin package"
AUTHOR = "Masaya Kataoka <ms.kataoka@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=fc216ef9336537897fbeafa564601763"

ROS_CN = "nmea_gps_plugin"
ROS_BPN = "nmea_gps_plugin"

ROS_BUILD_DEPENDS = " \
    gazebo \
    gazebo-ros \
    geodesy \
    geographic-msgs \
    libeigen \
    nmea-msgs \
    quaternion-operation \
    roscpp \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    gazebo \
    gazebo-ros \
    geodesy \
    geographic-msgs \
    libeigen \
    nmea-msgs \
    quaternion-operation \
    roscpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    gazebo \
    gazebo-ros \
    geodesy \
    libeigen \
    nmea-msgs \
    quaternion-operation \
    roscpp \
    rosdoc-lite \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/OUXT-Polaris/nmea_gps_plugin-release/archive/release/kinetic/nmea_gps_plugin/0.0.2-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "d112b1c09ddad028b64f1d02c0f37d7b"
SRC_URI[sha256sum] = "c20f1eb199a0cae99e3f43c3ad71538ae2d6b172d6d6faae2b9e0e0931a35b19"
S = "${WORKDIR}/nmea_gps_plugin-release-release-kinetic-nmea_gps_plugin-0.0.2-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('nmea-gps-plugin', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('nmea-gps-plugin', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/nmea-gps-plugin/nmea-gps-plugin_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/nmea-gps-plugin/nmea-gps-plugin-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/nmea-gps-plugin/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/nmea-gps-plugin/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

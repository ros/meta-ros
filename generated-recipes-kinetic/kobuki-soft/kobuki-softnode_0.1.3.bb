# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "ROS nodelet for fake Kobuki."
AUTHOR = "Jihoon Lee <jihoonlee.in@gmail.com>"
ROS_AUTHOR = "Jihoon Lee"
HOMEPAGE = "http://ros.org/wiki/kobuki"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "kobuki_soft"
ROS_BPN = "kobuki_softnode"

ROS_BUILD_DEPENDS = " \
    geometry-msgs \
    kobuki-msgs \
    nav-msgs \
    nodelet \
    roscpp \
    sensor-msgs \
    tf \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    diagnostic-aggregator \
    geometry-msgs \
    kobuki-description \
    kobuki-msgs \
    nav-msgs \
    nodelet \
    robot-state-publisher \
    roscpp \
    sensor-msgs \
    tf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    diagnostic-aggregator \
    geometry-msgs \
    kobuki-description \
    kobuki-msgs \
    nav-msgs \
    nodelet \
    robot-state-publisher \
    roscpp \
    sensor-msgs \
    tf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/yujinrobot-release/kobuki_soft-release/archive/release/kinetic/kobuki_softnode/0.1.3-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "b9de36d7b1ad166d2110c058c8828c28"
SRC_URI[sha256sum] = "4dfe45f4d62f9c3645046f4ef432126b33477a58ea95d4cee0db1128141be6e7"
S = "${WORKDIR}/kobuki_soft-release-release-kinetic-kobuki_softnode-0.1.3-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('kobuki-soft', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('kobuki-soft', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/kobuki-soft/kobuki-soft_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/kobuki-soft/kobuki-soft-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/kobuki-soft/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/kobuki-soft/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

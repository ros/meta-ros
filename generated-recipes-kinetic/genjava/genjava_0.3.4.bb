# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Java ROS message and service generators."
AUTHOR = "Daniel Stonier <d.stonier@gmail.com>"
ROS_AUTHOR = "Daniel Stonier"
HOMEPAGE = "http://www.ros.org/wiki/genjava"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "genjava"
ROS_BPN = "genjava"

ROS_BUILD_DEPENDS = " \
    genmsg \
    python-catkin-pkg \
    python-rospkg \
    rosjava-bootstrap \
    rosjava-build-tools \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    genmsg \
    python-catkin-pkg \
    python-rospkg \
    rosjava-bootstrap \
    rosjava-build-tools \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    genmsg \
    python-catkin-pkg \
    python-rospkg \
    rosjava-bootstrap \
    rosjava-build-tools \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/rosjava-release/genjava-release/archive/release/kinetic/genjava/0.3.4-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "ee68ad6b825af0efbae48d7c5287e140"
SRC_URI[sha256sum] = "a19f7d15fbd106a52180a34422c07cfd02e53070dee24380d2ed8c80678207d5"
S = "${WORKDIR}/genjava-release-release-kinetic-genjava-0.3.4-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('genjava', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('genjava', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/genjava/genjava_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/genjava/genjava-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/genjava/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/genjava/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

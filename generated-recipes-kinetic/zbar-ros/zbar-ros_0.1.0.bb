# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Lightweight ROS wrapper for Zbar barcode/qrcode reader library (http://zbar.sourceforge     .net/)"
AUTHOR = "Paul Bovbel <paul@bovbel.com>"
ROS_AUTHOR = "Paul Bovbel <paul@bovbel.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "zbar_ros"
ROS_BPN = "zbar_ros"

ROS_BUILD_DEPENDS = " \
    cv-bridge \
    nodelet \
    roscpp \
    roslint \
    zbar \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    cv-bridge \
    nodelet \
    roscpp \
    zbar \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    cv-bridge \
    nodelet \
    roscpp \
    zbar \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ros-drivers-gbp/zbar_ros-release/archive/release/kinetic/zbar_ros/0.1.0-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "58702065a433093c5e626c15b724af20"
SRC_URI[sha256sum] = "da54b1a1cfd82fd7c6686bfcf6ffc78e124db8c06e3ab3093a3952d95407bfa2"
S = "${WORKDIR}/zbar_ros-release-release-kinetic-zbar_ros-0.1.0-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('zbar-ros', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('zbar-ros', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/zbar-ros/zbar-ros_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/zbar-ros/zbar-ros-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/zbar-ros/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/zbar-ros/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

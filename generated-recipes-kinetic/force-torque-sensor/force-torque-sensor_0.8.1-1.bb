# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The force_torque_sensor package"
AUTHOR = "Denis Štogl <denis.stogl@kit.edu>"
HOMEPAGE = "https://github.com/KITrobotics/force_torque_sensor"
SECTION = "devel"
LICENSE = "LGPL-2"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=b691248d2f70cdaeeaf13696ada5d47c"

ROS_CN = "force_torque_sensor"
ROS_BPN = "force_torque_sensor"

ROS_BUILD_DEPENDS = " \
    cmake-modules \
    dynamic-reconfigure \
    geometry-msgs \
    hardware-interface \
    iirob-filters \
    pluginlib \
    realtime-tools \
    roscpp \
    rosparam-handler \
    rospy \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    cmake-modules \
    dynamic-reconfigure \
    geometry-msgs \
    hardware-interface \
    iirob-filters \
    pluginlib \
    realtime-tools \
    roscpp \
    rosparam-handler \
    rospy \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    cmake-modules \
    dynamic-reconfigure \
    geometry-msgs \
    hardware-interface \
    iirob-filters \
    message-runtime \
    pluginlib \
    realtime-tools \
    roscpp \
    rosparam-handler \
    rospy \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/KITrobotics/force_torque_sensor-release/archive/release/kinetic/force_torque_sensor/0.8.1-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "c80ec47e2c50eed2413fa1f3d85323b1"
SRC_URI[sha256sum] = "331470d3472ac076145b872aa59ba793f70dcd8285357277ac5fc92aadde4fe9"
S = "${WORKDIR}/force_torque_sensor-release-release-kinetic-force_torque_sensor-0.8.1-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('force-torque-sensor', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('force-torque-sensor', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/force-torque-sensor/force-torque-sensor_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/force-torque-sensor/force-torque-sensor-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/force-torque-sensor/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/force-torque-sensor/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

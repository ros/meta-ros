# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Cost maps, following the style of ethz-asl's grid_map library."
AUTHOR = "Daniel Stonier <d.stonier@gmail.com>"
ROS_AUTHOR = "Daniel Stonier"
HOMEPAGE = "https://github.com/stonier/cost_map"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "cost_map"
ROS_BPN = "cost_map_ros"

ROS_BUILD_DEPENDS = " \
    boost \
    cost-map-core \
    cost-map-msgs \
    costmap-2d \
    ecl-build \
    ecl-command-line \
    ecl-console \
    grid-map-core \
    grid-map-costmap-2d \
    grid-map-ros \
    grid-map-visualization \
    nav-msgs \
    opencv \
    roslib \
    yaml-cpp \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    boost \
    cost-map-core \
    cost-map-msgs \
    costmap-2d \
    ecl-build \
    ecl-command-line \
    ecl-console \
    grid-map-core \
    grid-map-costmap-2d \
    grid-map-ros \
    grid-map-visualization \
    nav-msgs \
    opencv \
    roslib \
    yaml-cpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    boost \
    cost-map-core \
    cost-map-msgs \
    costmap-2d \
    ecl-build \
    ecl-command-line \
    ecl-console \
    grid-map-core \
    grid-map-costmap-2d \
    grid-map-ros \
    grid-map-visualization \
    nav-msgs \
    opencv \
    roslib \
    yaml-cpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/stonier/cost_map-release/archive/release/kinetic/cost_map_ros/0.3.3-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "17c2e175cf6509bde258e0ce34cb9f7a"
SRC_URI[sha256sum] = "79e23bddf96227bb9047882efe9ab159aadc3597cdaa61dc93e3143bc5df40e7"
S = "${WORKDIR}/cost_map-release-release-kinetic-cost_map_ros-0.3.3-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('cost-map', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('cost-map', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/cost-map/cost-map_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/cost-map/cost-map-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/cost-map/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/cost-map/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

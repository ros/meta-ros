# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Wrapper interface for tracing libraries"
AUTHOR = "Ingo Luetkebohle <ingo.luetkebohle@de.bosch.com>"
ROS_AUTHOR = "Ingo Luetkebohle <ingo.luetkebohle@de.bosch.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "APLv2"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=7b404913b4819f2321770961dc72a54f"

ROS_CN = "tracetools"
ROS_BPN = "tracetools"

ROS_BUILD_DEPENDS = " \
    boost \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
    pkgconfig-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = ""

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    rosbash \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/bosch-robotics-cr/tracetools-release/archive/release/kinetic/tracetools/0.2.1-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "13172b68a84fc272681f92bb7c71e1ec"
SRC_URI[sha256sum] = "0c51e131b0461a9aeb8822e368147433d331bbf9c972062f775d9f4e73a0636e"
S = "${WORKDIR}/tracetools-release-release-kinetic-tracetools-0.2.1-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('tracetools', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('tracetools', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/tracetools/tracetools_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/tracetools/tracetools-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/tracetools/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/tracetools/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

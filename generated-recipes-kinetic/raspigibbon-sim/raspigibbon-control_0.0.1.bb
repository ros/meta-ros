# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The raspigibbon_control package"
AUTHOR = "RT Corporation <shop@rt-net.jp>"
ROS_AUTHOR = "Daisuke Sato <tiryoh@gmail.com>"
HOMEPAGE = "http://github.com/rt-net/RaspberryPiGibbon/wiki"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=2c00b8d2854109dbebef7818b4dae1e2"

ROS_CN = "raspigibbon_sim"
ROS_BPN = "raspigibbon_control"

ROS_BUILD_DEPENDS = " \
    control-msgs \
    controller-interface \
    controller-manager \
    gazebo-ros-control \
    hardware-interface \
    joint-state-controller \
    robot-state-publisher \
    rospy \
    sensor-msgs \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    control-msgs \
    controller-interface \
    controller-manager \
    gazebo-ros-control \
    hardware-interface \
    joint-state-controller \
    robot-state-publisher \
    rospy \
    sensor-msgs \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    control-msgs \
    controller-interface \
    controller-manager \
    gazebo-ros-control \
    hardware-interface \
    joint-state-controller \
    robot-state-publisher \
    rospy \
    sensor-msgs \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/raspberrypigibbon/raspigibbon_sim-release/archive/release/kinetic/raspigibbon_control/0.0.1-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "a6810bf03d6f8594a6e5f3b2e3e05ca4"
SRC_URI[sha256sum] = "36bc3da52cdc538b0e3bebacad479a2bf8718d415b69668a20ea49d30af7e8c6"
S = "${WORKDIR}/raspigibbon_sim-release-release-kinetic-raspigibbon_control-0.0.1-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('raspigibbon-sim', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('raspigibbon-sim', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/raspigibbon-sim/raspigibbon-sim_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/raspigibbon-sim/raspigibbon-sim-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/raspigibbon-sim/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/raspigibbon-sim/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

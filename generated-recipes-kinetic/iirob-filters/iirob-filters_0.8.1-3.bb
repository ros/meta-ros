# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The iirob_filters package implements following filters:       1) Low-Pass       2) Moving Mean       3) Gravity Compensation (used for force-torque sensors)       4) Threshold Filter       5) Kalman Filter"
AUTHOR = "Denis Štogl <denis.stogl@kit.edu>"
ROS_AUTHOR = "Denis Štogl <denis.stogl@kit.edu>"
HOMEPAGE = "http://wiki.ros.org/iirob_filters"
SECTION = "devel"
LICENSE = "LGPL-2"
LIC_FILES_CHKSUM = "file://package.xml;beginline=15;endline=15;md5=b691248d2f70cdaeeaf13696ada5d47c"

ROS_CN = "iirob_filters"
ROS_BPN = "iirob_filters"

ROS_BUILD_DEPENDS = " \
    cmake-modules \
    dynamic-reconfigure \
    eigen-conversions \
    filters \
    geometry-msgs \
    pluginlib \
    roscpp \
    rosparam-handler \
    rostest \
    tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    cmake-modules \
    dynamic-reconfigure \
    eigen-conversions \
    filters \
    geometry-msgs \
    pluginlib \
    roscpp \
    rosparam-handler \
    rostest \
    tf2-ros \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    cmake-modules \
    dynamic-reconfigure \
    eigen-conversions \
    filters \
    geometry-msgs \
    pluginlib \
    roscpp \
    rosparam-handler \
    rostest \
    tf2-ros \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/KITrobotics/iirob_filters-release/archive/release/kinetic/iirob_filters/0.8.1-3.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "b33708ec008f579fdabc1fd3765a5d91"
SRC_URI[sha256sum] = "f083c70688f848452c3c68ac030b5ecf36bd7899a36331eadf1f6132954dca79"
S = "${WORKDIR}/iirob_filters-release-release-kinetic-iirob_filters-0.8.1-3"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('iirob-filters', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('iirob-filters', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/iirob-filters/iirob-filters_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/iirob-filters/iirob-filters-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/iirob-filters/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/iirob-filters/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Traceback fiddling library. Allows you to pickle tracebacks."
AUTHOR = "AlexV <asmodehn@gmail.com>"
ROS_AUTHOR = "Ionel Cristian Mărieș"
HOMEPAGE = "https://github.com/ionelmc/python-tblib"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "tblib"
ROS_BPN = "tblib"

ROS_BUILD_DEPENDS = " \
    catkin-pip \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = ""

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/asmodehn/tblib-rosrelease/archive/release/kinetic/tblib/1.2.0-2.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "42120214b014e1183bb87a763e454fc5"
SRC_URI[sha256sum] = "0e67c67bba4e7339bda61ef3f8ada290a0374da8b8e46670215bc41080f179c1"
S = "${WORKDIR}/tblib-rosrelease-release-kinetic-tblib-1.2.0-2"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('tblib', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('tblib', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/tblib/tblib_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/tblib/tblib-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/tblib/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/tblib/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

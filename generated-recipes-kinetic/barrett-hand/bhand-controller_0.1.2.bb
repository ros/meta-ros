# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The bhand_controller package is intended to control the Barrett Hand"
AUTHOR = "Román Navarro <rnavarro@robotnik.es>"
ROS_AUTHOR = "Román Navarro <rnavarro@robotnik.es>"
HOMEPAGE = "http://wiki.ros.org/bhand_controller"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "barrett_hand"
ROS_BPN = "bhand_controller"

ROS_BUILD_DEPENDS = " \
    genmsg \
    rospy \
    sensor-msgs \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    genmsg \
    rospy \
    sensor-msgs \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    genmsg \
    rospy \
    sensor-msgs \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/RobotnikAutomation/barrett_hand-release/archive/release/kinetic/bhand_controller/0.1.2-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "e1b868d918dbc8aa629934944d346d18"
SRC_URI[sha256sum] = "9d549005a71830ddb6024662bfc5e2202f9f5ca47b0c289964e0f6c0951d1378"
S = "${WORKDIR}/barrett_hand-release-release-kinetic-bhand_controller-0.1.2-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('barrett-hand', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('barrett-hand', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/barrett-hand/barrett-hand_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/barrett-hand/barrett-hand-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/barrett-hand/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/barrett-hand/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

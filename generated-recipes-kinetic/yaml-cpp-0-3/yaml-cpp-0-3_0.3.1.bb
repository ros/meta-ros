# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Legacy version of yaml cpp without boost, namespaced to avoid system conflicts."
AUTHOR = "Daniel Stonier <d.stonier@gmail.com>"
ROS_AUTHOR = "Google"
HOMEPAGE = "https://github.com/stonier/yaml_cpp_0_3"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "yaml_cpp_0_3"
ROS_BPN = "yaml_cpp_0_3"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = ""

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/yujinrobot-release/yaml_cpp_0_3-release/archive/release/kinetic/yaml_cpp_0_3/0.3.1-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "3467b4260691068f54f5e3ee2695112d"
SRC_URI[sha256sum] = "434e23ecd0af3c87b26327868dfdc51f662cb9eef6b8adfc4cbf191dd2931a36"
S = "${WORKDIR}/yaml_cpp_0_3-release-release-kinetic-yaml_cpp_0_3-0.3.1-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('yaml-cpp-0-3', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('yaml-cpp-0-3', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/yaml-cpp-0-3/yaml-cpp-0-3_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/yaml-cpp-0-3/yaml-cpp-0-3-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/yaml-cpp-0-3/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/yaml-cpp-0-3/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

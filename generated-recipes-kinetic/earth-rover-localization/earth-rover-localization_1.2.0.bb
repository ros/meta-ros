# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Configuration for the EKF of the robot_localization package to use with the Earth Rover Open Agribot."
AUTHOR = "Andres Palomino <andres@earthrover.cc>"
HOMEPAGE = "http://open.earthrover.cc/"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=2c00b8d2854109dbebef7818b4dae1e2"

ROS_CN = "earth_rover_localization"
ROS_BPN = "earth_rover_localization"

ROS_BUILD_DEPENDS = " \
    geographiclib \
    geographiclib-tools \
    piksi-multi-rtk \
    piksi-rtk-msgs \
    robot-localization \
    roscpp \
    rospy \
    std-msgs \
    tf \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    geographiclib \
    geographiclib-tools \
    piksi-multi-rtk \
    piksi-rtk-msgs \
    robot-localization \
    roscpp \
    rospy \
    std-msgs \
    tf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    piksi-multi-rtk \
    piksi-rtk-msgs \
    robot-localization \
    roscpp \
    rospy \
    std-msgs \
    tf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/earthrover/earth_rover_localization-release/archive/release/kinetic/earth_rover_localization/1.2.0-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "51133c0b9e275a41731c28ed90d95432"
SRC_URI[sha256sum] = "9e513c990da16d51f4c1b2c4f80097c9ec816509d8f03c65ab6329333a5bc3e6"
S = "${WORKDIR}/earth_rover_localization-release-release-kinetic-earth_rover_localization-1.2.0-0"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('earth-rover-localization', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('earth-rover-localization', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/earth-rover-localization/earth-rover-localization_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/earth-rover-localization/earth-rover-localization-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/earth-rover-localization/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/earth-rover-localization/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

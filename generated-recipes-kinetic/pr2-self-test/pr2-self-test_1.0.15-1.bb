# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "The pr2_self_test package"
AUTHOR = "David Feil-Seifer <dave@cse.unr.edu>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "TODO"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=2c00b8d2854109dbebef7818b4dae1e2"

ROS_CN = "pr2_self_test"
ROS_BPN = "pr2_self_test"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    joint-qualification-controllers \
    pr2-bringup-tests \
    pr2-counterbalance-check \
    pr2-self-test-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    joint-qualification-controllers \
    pr2-bringup-tests \
    pr2-counterbalance-check \
    pr2-self-test-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/pr2-gbp/pr2_self_test-release/archive/release/kinetic/pr2_self_test/1.0.15-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "c51da757627df8a44669594b4403e27c"
SRC_URI[sha256sum] = "da8b4872ab5bc73b0cd6350212c630ddb85b5461841a7214a56d4678411bf875"
S = "${WORKDIR}/pr2_self_test-release-release-kinetic-pr2_self_test-1.0.15-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('pr2-self-test', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('pr2-self-test', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pr2-self-test/pr2-self-test_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pr2-self-test/pr2-self-test-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pr2-self-test/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pr2-self-test/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

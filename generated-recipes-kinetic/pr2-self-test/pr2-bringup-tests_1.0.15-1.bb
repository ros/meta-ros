# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Complete functionality tests for PR2. Contains utilities designed to test and verify devices, mechanicals and sensors."
AUTHOR = "David Feil-Seifer <dave@cse.unr.edu>"
ROS_AUTHOR = "Kevin Watts"
HOMEPAGE = "http://ros.org/wiki/pr2_bringup_tests"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "pr2_self_test"
ROS_BPN = "pr2_bringup_tests"

ROS_BUILD_DEPENDS = " \
    camera-calibration \
    ethercat-trigger-controllers \
    image-view \
    pr2-bringup \
    pr2-controller-manager \
    pr2-mannequin-mode \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    camera-calibration \
    ethercat-trigger-controllers \
    image-view \
    pr2-bringup \
    pr2-controller-manager \
    pr2-mannequin-mode \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    camera-calibration \
    ethercat-trigger-controllers \
    image-view \
    pr2-bringup \
    pr2-controller-manager \
    pr2-mannequin-mode \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/pr2-gbp/pr2_self_test-release/archive/release/kinetic/pr2_bringup_tests/1.0.15-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "922e3d4b0099da381e539f73cb0d6ff2"
SRC_URI[sha256sum] = "fe60f794d6d5e1881b7738e06cbab7560c6cb163457be0e3312aea022e3a1745"
S = "${WORKDIR}/pr2_self_test-release-release-kinetic-pr2_bringup_tests-1.0.15-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('pr2-self-test', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('pr2-self-test', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pr2-self-test/pr2-self-test_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pr2-self-test/pr2-self-test-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pr2-self-test/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/pr2-self-test/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

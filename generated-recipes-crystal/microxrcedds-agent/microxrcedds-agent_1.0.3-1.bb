# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "DDS-XCRE agent implementation"
AUTHOR = "Borja Outerelo <borjaouterelo@eprosima.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "microxrcedds_agent"
ROS_BPN = "microxrcedds_agent"

ROS_BUILD_DEPENDS = " \
    asio \
    fastcdr \
    fastrtps \
"

ROS_BUILDTOOL_DEPENDS = " \
    cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    fastcdr \
    fastrtps \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    fastcdr \
    fastrtps \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/micro-ROS/microxrcedds_agent-release/archive/release/crystal/microxrcedds_agent/1.0.3-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "cb5ac9461e4e8668e0e88159a4bbeceb"
SRC_URI[sha256sum] = "e803c907ee996f9fe855a0eb232a56bdbdb0bb29b891abe8966c036683afc205"
S = "${WORKDIR}/microxrcedds_agent-release-release-crystal-microxrcedds_agent-1.0.3-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('microxrcedds-agent', d)}"
ROS_BUILD_TYPE = "cmake"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('microxrcedds-agent', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/microxrcedds-agent/microxrcedds-agent_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/microxrcedds-agent/microxrcedds-agent-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/microxrcedds-agent/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/microxrcedds-agent/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

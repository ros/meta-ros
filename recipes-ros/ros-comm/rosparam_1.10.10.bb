DESCRIPTION = "the rosparam command-line tool for getting and setting ROS Parameters on the \
Parameter Server using YAML-encoded files."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=15;endline=15;md5=d566ef916e9dedc494f5f793a6690ba5"

require ros-comm.inc

ROS_PKG_SUBDIR = "tools"

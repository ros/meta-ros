DESCRIPTION = "A Python and C++ implementation of the LZ4 streaming format."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "lz4"

require ros-comm.inc

ROS_PKG_SUBDIR = "utilities"

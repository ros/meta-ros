DESCRIPTION = "Controller to publish state of force-torque sensors."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "controller-interface control-msgs control-toolbox realtime-tools urdf forward-command-controller dynamic-reconfigure urdfdom"

require ros-controllers.inc

DESCRIPTION = "Controller to publish state of IMU sensors"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "realtime-tools roscpp hardware-interface pluginlib controller-interface sensor-msgs"

require ros-controllers.inc

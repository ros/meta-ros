DESCRIPTION = "forward_command_controller."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "controller-interface hardware-interface realtime-tools std-msgs"

require ros-controllers.inc

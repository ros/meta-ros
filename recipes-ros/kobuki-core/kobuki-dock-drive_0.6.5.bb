DESCRIPTION = "Dock driving library for Kobuki."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-build ecl-threads ecl-geometry ecl-linear-algebra"

require kobuki-core.inc

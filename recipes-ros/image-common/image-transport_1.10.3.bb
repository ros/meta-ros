DESCRIPTION = "image_transport should always be used to subscribe to and publish images."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=68b329da9893e34099c7d8ad5cb9c940"

DEPENDS = "message-filters pluginlib rosconsole roscpp roslib sensor-msgs"

require image-common.inc


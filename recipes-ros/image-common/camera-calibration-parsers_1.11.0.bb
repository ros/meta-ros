DESCRIPTION = "camera_calibration_parsers contains routines for reading and writing camera calibration parameters."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "boost rosconsole sensor-msgs yaml-cpp"

require image-common.inc

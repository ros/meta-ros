DESCRIPTION = "Interface for enforcing joint limits."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=6;endline=6;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "roscpp hardware-interface urdfdom"

require ros-control.inc

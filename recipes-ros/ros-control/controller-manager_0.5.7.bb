DESCRIPTION = "The controller manager."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "controller-interface controller-manager-msgs hardware-interface realtime-tools pluginlib"

require ros-control.inc


DESCRIPTION = "Collecting, tracking and generating statistics for ar markers from ar_track_alvar."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ar-track-alvar-msgs roscpp geometry-msgs sensor-msgs yaml-cpp yocs-math-toolkit"

require yujin-ocs.inc

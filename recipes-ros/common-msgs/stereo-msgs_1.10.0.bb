DESCRIPTION = "stereo_msgs contains messages specific to stereo processing, \
such as disparity images."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "sensor-msgs"

require common-msgs.inc

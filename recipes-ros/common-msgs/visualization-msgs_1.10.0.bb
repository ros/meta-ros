DESCRIPTION = "visualization_msgs is a set of messages used by higher level \
packages, such as rviz, that deal in visualization-specific data."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "geometry-msgs"

require common-msgs.inc

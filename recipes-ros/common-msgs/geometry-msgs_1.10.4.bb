DESCRIPTION = "geometry_msgs provides messages for common geometric primitives \
such as points, vectors, and poses."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

require common-msgs.inc

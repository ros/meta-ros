DESCRIPTION = "This package holds the diagnostic messages which provide the \
standardized interface for the diagnostic and runtime monitoring systems in ROS."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=17;endline=17;md5=d566ef916e9dedc494f5f793a6690ba5"

require common-msgs.inc

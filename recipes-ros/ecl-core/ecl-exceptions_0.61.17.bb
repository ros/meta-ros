DESCRIPTION = "Template based exceptions - these are simple and practical and avoid the proliferation of exception types."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-license ecl-config ecl-errors"

require ecl-core.inc

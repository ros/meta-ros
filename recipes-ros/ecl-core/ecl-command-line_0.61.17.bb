DESCRIPTION = "Embeds the TCLAP library inside the ecl. This is a very convenient \
  command line parser in templatised c++."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-license"

require ecl-core.inc

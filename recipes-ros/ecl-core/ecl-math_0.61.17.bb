DESCRIPTION = "This package provides simple support to cmath, filling in holes \
  or redefining in a c++ formulation where desirable."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-license ecl-type-traits"

require ecl-core.inc

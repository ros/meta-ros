DESCRIPTION = "Metaprogramming tools move alot of runtime calculations to be shifted to compile time."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-license"

require ecl-core.inc

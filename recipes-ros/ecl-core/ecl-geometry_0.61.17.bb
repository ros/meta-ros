DESCRIPTION = "Any tools relating to mathematical geometry."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-build ecl-license ecl-config ecl-type-traits ecl-containers ecl-formatters ecl-linear-algebra ecl-exceptions ecl-math ecl-mpl"

require ecl-core.inc

DESCRIPTION = "This provides an Eigen implementation for ecl's linear algebra."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "cmake-modules ecl-license libeigen"

require ecl-core.inc

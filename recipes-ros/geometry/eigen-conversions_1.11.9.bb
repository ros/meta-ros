DESCRIPTION = "Conversion functions between Eigen and KDL, and Eigen and geometry_msgs."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=15;endline=15;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "cmake-modules geometry-msgs libeigen orocos-kdl std-msgs"

require geometry.inc

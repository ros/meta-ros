DESCRIPTION = "Conversion functions between KDL and geometry_msgs types."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "geometry-msgs orocos-kdl"

require geometry.inc

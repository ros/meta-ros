DESCRIPTION = "Most implementations (windows, posix, ...) have slightly different api for low level input-output functions."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-license ecl-config ecl-errors"

require ecl-lite.inc

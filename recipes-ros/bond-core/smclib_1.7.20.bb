DESCRIPTION = "\
The State Machine Compiler (SMC) from http://smc.sourceforge.net/ \
converts a language-independent description of a state machine \
into the source code to support that state machine. \
This package contains the libraries that a compiled state machine \
depends on, but it does not contain the compiler itself. \
"
SECTION = "devel"
LICENSE = "MPL-1.1"
LIC_FILES_CHKSUM = "file://package.xml;beginline=15;endline=15;md5=e1b5a50d4dd59d8102e41a7a2254462d"

require bond-core.inc

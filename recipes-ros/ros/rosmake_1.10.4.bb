DESCRIPTION = "rosmake is a ros dependency aware build tool which can be used to build all dependencies in the correct order."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

require ros.inc

ROS_PKG_SUBDIR = "tools"

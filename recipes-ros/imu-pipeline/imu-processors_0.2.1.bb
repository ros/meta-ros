DESCRIPTION = "Processors for sensor_msgs::Imu data"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=6;endline=6;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "roscpp sensor-msgs geometry-msgs nav-msgs tf"

require imu-pipeline.inc

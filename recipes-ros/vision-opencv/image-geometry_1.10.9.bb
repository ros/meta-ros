DESCRIPTION = "`image_geometry` contains C++ and Python libraries for interpreting images geometrically."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "opencv sensor-msgs"

require vision-opencv.inc

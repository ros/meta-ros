DESCRIPTION = "actionlib_tutorials, recipe for cross-compiling ROS package"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;md5=c26f9322eca1f135394a88a9e245ceef"

DEPENDS = "roscpp actionlib message-generation std-msgs actionlib-msgs"

require common-tutorials.inc

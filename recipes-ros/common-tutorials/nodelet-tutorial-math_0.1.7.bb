DESCRIPTION = "nodelet_tutorial_math, recipe for cross-compiling ROS package"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;md5=e070f6c08fc4fa9b2232522b5562cc71"

DEPENDS = "roscpp nodelet std-msgs"
RDEPENDS = "roscpp nodelet std-msgs"

require common-tutorials.inc

DESCRIPTION = "pluginlib_tutorials, recipe for cross-compiling ROS package"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;md5=e3f57c5834129196ac5fa3f99a8c14c6"

DEPENDS = "roscpp pluginlib"
RDEPENDS = "roscpp pluginlib"

require common-tutorials.inc

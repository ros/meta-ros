DESCRIPTION = "KDL binding for tf2"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "libeigen orocos-kdl tf2 tf2-ros cmake-modules"

require geometry2.inc

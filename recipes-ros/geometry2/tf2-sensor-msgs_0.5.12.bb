DESCRIPTION = "Small lib to transform sensor_msgs with tf"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "cmake-modules libeigen sensor-msgs tf2-ros tf2"

require geometry2.inc

DESCRIPTION = "voxel_grid provides an implementation of an efficient 3D voxel grid."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=01c2bc31767ccb3a68e12f02612b2a97"

DEPENDS = "roscpp"

require navigation.inc

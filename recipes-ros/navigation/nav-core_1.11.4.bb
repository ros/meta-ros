DESCRIPTION = "This package provides common interfaces for navigation specific robot actions."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=01c2bc31767ccb3a68e12f02612b2a97"

DEPENDS = "costmap-2d geometry-msgs std-msgs tf"

require navigation.inc

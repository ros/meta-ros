DESCRIPTION = "diagnostic_updater contains tools for easily updating diagnostics."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "diagnostic-msgs roscpp std-msgs"

require diagnostics.inc

DESCRIPTION = "The diagnostic_analysis package can convert a log of diagnostics data into a series of CSV files."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "diagnostic-updater rospy"

require diagnostics.inc

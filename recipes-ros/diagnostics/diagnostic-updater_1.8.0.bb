DESCRIPTION = "diagnostic_updater contains tools for easily updating diagnostics."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "diagnostic-msgs roscpp rostest std-msgs"

require diagnostics.inc

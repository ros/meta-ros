DESCRIPTION = "Libraries and examples for ROSserial usage on Arduino/AVR Platforms."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "std-msgs sensor-msgs geometry-msgs nav-msgs rosserial-client message-generation"

require rosserial.inc

DESCRIPTION = "tools to do point to multipoint communication between rosserial nodes connected to an xbee."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=17;endline=17;md5=d566ef916e9dedc494f5f793a6690ba5"

require rosserial.inc

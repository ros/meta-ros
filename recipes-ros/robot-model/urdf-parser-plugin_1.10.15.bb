DESCRIPTION = "This package contains a C++ base class for URDF parsers"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "urdfdom-headers"

require robot-model.inc


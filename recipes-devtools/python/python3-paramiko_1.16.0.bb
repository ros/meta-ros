require python-paramiko.inc

inherit setuptools3

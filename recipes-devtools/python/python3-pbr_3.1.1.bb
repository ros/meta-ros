require python-pbr.inc

inherit setuptools3

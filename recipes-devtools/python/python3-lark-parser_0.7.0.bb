# Copyright (c) 2019 LG Electronics, Inc.

# Copyright (c) 2019 LG Electronics, Inc.

require python-lark-parser.inc

inherit setuptools3

require python-catkin-pkg.inc

inherit distutils

BBCLASSEXTEND = "native nativesdk"

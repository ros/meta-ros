require python-ecdsa.inc

inherit setuptools3

include python-pycrypto.inc

inherit distutils3

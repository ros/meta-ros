require python-empy.inc

inherit distutils

BBCLASSEXTEND = "native nativesdk"

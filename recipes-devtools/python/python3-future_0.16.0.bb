require python-future.inc

inherit setuptools3

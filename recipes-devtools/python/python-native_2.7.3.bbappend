RPROVIDES += "python-datetime-native python-netclient-native python-subprocess-native python-xml-native"

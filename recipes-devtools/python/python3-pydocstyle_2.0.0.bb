# Copyright (c) 2019 LG Electronics, Inc.

require python-pydocstyle.inc

inherit setuptools3

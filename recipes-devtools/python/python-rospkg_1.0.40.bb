require python-rospkg.inc

inherit setuptools

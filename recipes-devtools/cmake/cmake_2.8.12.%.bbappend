FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://cmake-2.8.12.2-FindBoost.patch"

FILES_${PN}-dev_class-nativesdk = ""

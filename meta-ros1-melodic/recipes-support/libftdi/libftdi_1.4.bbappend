# Copyright (c) 2020 LG Electronics, Inc.

# needed for epos2-motor-controller and maybe other recipes
PACKAGECONFIG += "cpp-wrapper"

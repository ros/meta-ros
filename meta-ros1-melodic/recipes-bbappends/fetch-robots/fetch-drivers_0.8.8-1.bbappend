# Copyright (c) 2020 LG Electronics, Inc.

# NOTE: VERBOSE=1 cmake --build /jenkins/mjansa/build/ros/webos-melodic-thud/tmp-glibc/work/qemux86-webos-linux/fetch-drivers/0.8.8-1-r0/build --target all -- -j 80
# ninja: error: build.ninja:111: bad $-escape (literal $ must be written as $$)
OECMAKE_GENERATOR = "Unix Makefiles"

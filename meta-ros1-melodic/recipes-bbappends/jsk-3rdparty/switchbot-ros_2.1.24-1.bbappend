# Copyright (c) 2021 LG Electronics, Inc.

DEPENDS += "actionlib-msgs"

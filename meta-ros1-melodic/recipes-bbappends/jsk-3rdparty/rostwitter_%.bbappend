# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[rostwitter] ?= "Depends on unavailable UNRESOLVED-python-requests-oauthlib"

# Copyright (c) 2019 LG Electronics, Inc.

# Depends on (voice-text,julius-ros)->sound-play which depends on gstreamer1.0-plugins-ugly with this restriction:
LICENSE_FLAGS = "commercial"

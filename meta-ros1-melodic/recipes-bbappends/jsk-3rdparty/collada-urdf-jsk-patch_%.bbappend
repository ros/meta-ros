# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[collada-urdf-jsk-patch] ?= "Depends on unavailable UNRESOLVED-python-catkin-tools"

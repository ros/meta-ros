# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[respeaker-ros] ?= "Depends on unavailable UNRESOLVED-python-pyusb-pip, UNRESOLVED-python-speechrecognition-pip"

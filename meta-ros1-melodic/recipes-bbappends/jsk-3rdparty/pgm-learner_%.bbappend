# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[pgm-learner] ?= "Depends on unavailable UNRESOLVED-python-libpgm-pip, UNRESOLVED-python-scipy"

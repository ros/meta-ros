# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[wifi-ddwrt] ?= "Depends on unavailable UNRESOLVED-python-mechanize"

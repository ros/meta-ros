# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[calibration-estimation] ?= "Depends on unavailable UNRESOLVED-python-scipy"

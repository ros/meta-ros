# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[calibration] ?= "depends on calibration-estimation which depends on unavailable UNRESOLVED-python-scipy"

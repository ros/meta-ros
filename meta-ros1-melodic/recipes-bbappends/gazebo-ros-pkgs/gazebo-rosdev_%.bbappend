# Copyright (c) 2019 LG Electronics, Inc.

# XXX Conditionalize on DISTRO_FEATURES?
DEPENDS_remove = "libgazebo9"

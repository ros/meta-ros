# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[vapor-master] ?= "Depends on unavailable UNRESOLVED-npm-native"

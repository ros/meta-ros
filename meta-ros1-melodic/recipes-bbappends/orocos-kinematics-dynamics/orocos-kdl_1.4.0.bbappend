# Copyright (c) 2019 LG Electronics, Inc.

# Missing license version in package.xml maps it to invalid LGPL-2
# https://github.com/orocos/orocos-kdl-release/issues/4
LICENSE = "LGPL-2.1"

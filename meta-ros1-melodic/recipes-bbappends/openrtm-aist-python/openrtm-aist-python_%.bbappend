# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[openrtm-aist-python] ?= "Depends on unavailable UNRESOLVED-python-omniorb"

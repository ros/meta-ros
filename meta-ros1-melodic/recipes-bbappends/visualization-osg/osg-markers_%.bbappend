# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[osg-markers] ?= "Depends on unavailable UNRESOLVED-libopenscenegraph"

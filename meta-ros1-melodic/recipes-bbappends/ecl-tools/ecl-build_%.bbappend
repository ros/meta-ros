# Copyright (c) 2019 LG Electronics, Inc.

FILES_${PN}-dev_prepend = "${datadir}/cmake "

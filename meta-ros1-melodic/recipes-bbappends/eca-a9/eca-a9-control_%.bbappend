# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[eca-a9-control] ?= "Rdepends on uuv-trajectory-control which rdepends on unavailable UNRESOLVED-python-scipy"

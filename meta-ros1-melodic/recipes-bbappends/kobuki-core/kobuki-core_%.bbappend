# Copyright (c) 2020 LG Electronics, Inc.

# kobuki-ftdi is blacklisted
ROS_EXPORT_DEPENDS:remove = "kobuki-ftdi"
ROS_EXEC_DEPENDS:remove = "kobuki-ftdi"

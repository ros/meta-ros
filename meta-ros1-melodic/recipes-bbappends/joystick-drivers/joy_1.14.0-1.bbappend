# Copyright (c) 2019 LG Electronics, Inc.

# "joy" builds fine without this dependency.
DEPENDS_remove = "joystick"
RDEPENDS_${PN}_remove = "joystick"

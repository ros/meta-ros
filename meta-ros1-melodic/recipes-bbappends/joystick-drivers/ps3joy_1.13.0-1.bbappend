# Copyright (c) 2020 LG Electronics, Inc.

DEPENDS += "libusb-compat"

# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[spacenav-node] ?= "Depends on unavailable UNRESOLVED-libspnav-dev"

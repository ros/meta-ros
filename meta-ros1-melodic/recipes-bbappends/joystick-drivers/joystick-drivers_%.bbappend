# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[joystick-driver] ?= "Depends on wiimote which depends on unavailable UNRESOLVED-python-cwiid"

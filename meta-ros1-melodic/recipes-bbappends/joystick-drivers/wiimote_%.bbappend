# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[wiimote] ?= "Depends on unavailable UNRESOLVED-python-cwiid"

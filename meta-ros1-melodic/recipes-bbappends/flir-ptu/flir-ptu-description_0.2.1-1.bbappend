# Copyright (c) 2021 LG Electronics, Inc.

DEPENDS += "xacro-native"

# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[network-autoconfig] ?= "Rdepends on unavailable UNRESOLVED-network-manager"

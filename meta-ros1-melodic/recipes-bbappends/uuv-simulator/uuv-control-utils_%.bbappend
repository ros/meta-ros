# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[uuv-control-utils] ?= "Rdepends on uuv-trajectory-control which rdepends on unavailable UNRESOLVED-python-scipy"

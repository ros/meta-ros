# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[uuv-trajectory-control] ?= "Rdepends on unavailable UNRESOLVED-python-scipy"

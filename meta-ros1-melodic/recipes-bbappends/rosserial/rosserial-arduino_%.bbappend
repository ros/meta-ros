# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[rosserial-arduino] ?= "Depends on unavailable UNRESOLVED-arduino-core"

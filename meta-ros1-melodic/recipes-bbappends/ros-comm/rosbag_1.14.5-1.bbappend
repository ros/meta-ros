# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILD_DEPENDS_remove = "${ROS_UNRESOLVED_PLATFORM_PKG_python-imaging}"

# Copyright (c) 2019 LG Electronics, Inc.

# XXX No Lisp support for now.
ROS_EXPORT_DEPENDS_remove = "roslisp"
ROS_EXEC_DEPENDS_remove = "roslisp"

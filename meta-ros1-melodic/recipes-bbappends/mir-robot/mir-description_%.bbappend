# Copyright (c) 2020 LG Electronics, Inc.

# Depends on gazebo-ros-control with this restriction:
inherit features_check
REQUIRED_DISTRO_FEATURES = "ros-gazebo"

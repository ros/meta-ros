# Copyright (c) 2020 LG Electronics, Inc.

# Rdepends on ros-reflexxes with this restriction
COMPATIBLE_MACHINE = "(^$)"
COMPATIBLE_MACHINE:x86-64 = "(.*)"

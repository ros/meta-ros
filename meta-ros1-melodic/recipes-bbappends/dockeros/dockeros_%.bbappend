# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[dockeros] ?= "Depends on unavailable UNRESOLVED-python-docker"

# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[roseus-tutorials] ?= "depends on roseus which depends on blacklisted geneus, euslisp"

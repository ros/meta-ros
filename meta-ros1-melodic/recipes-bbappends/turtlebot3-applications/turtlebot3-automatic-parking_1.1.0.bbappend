# Copyright (c) 2019 LG Electronics, Inc.

# From: http://emanual.robotis.com/docs/en/platform/turtlebot3/applications/#automatic-parking:
RDEPENDS:${PN}:append = " \
    ${PYTHON_PN}-numpy \
"

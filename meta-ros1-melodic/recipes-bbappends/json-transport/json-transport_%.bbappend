# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[json-transport] ?= "Rdepends on unavailable UNRESOLVED-python-msgpack"

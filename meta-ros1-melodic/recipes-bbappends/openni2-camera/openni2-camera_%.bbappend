# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[openni2-camera] ?= "Depends on unavailable UNRESOLVED-libopenni2-dev"

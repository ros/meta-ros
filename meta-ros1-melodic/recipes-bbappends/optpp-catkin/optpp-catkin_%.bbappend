# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[optpp-catkin] ?= "Depends on unavailable UNRESOLVED-gfortran"

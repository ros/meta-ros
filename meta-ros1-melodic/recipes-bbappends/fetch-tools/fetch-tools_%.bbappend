# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[fetch-tools] ?= "Rdepends on unavailable UNRESOLVED-python-catkin-lint, UNRESOLVED-python-argcomplete"

# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[spatio-temporal-voxel-layer] ?= "Depends on unavailable UNRESOLVED-libopenvdb, UNRESOLVED-libopenexr-dev, UNRESOLVED-libopenvdb-dev"

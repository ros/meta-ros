# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[catkin-virtualenv] ?= "Requires Python 3; it is not used by any other ROS 1 package."

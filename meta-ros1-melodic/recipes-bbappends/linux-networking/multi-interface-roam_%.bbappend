# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[multi-interface-roam] ?= "Depends on unavailable python-twisted-core"

ROS_BUILD_DEPENDS += " \
    ${PYTHON_PN}-pyyaml-native \
"

# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[rosdoc-lite] ?= "Generation of ROS package documentation will never be done on the target."

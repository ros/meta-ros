# Copyright (c) 2020 LG Electronics, Inc.

# Depends on cob-description, raw-description with this restriction:
inherit distro_features_check
REQUIRED_DISTRO_FEATURES = "ros-gazebo"

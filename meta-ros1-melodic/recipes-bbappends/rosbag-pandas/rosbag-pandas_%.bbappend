# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[rosbag-pandas] ?= "Rdepends on unavailable UNRESOLVED-python-pandas"

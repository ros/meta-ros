# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[nao-meshes] ?= "Depends on unavailable UNRESOLVED-java"

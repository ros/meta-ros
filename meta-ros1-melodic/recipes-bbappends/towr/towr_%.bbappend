# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[towr] ?= "Depends on ifopt which depends on unavailable UNRESOLVED-coinor-libipopt-dev"

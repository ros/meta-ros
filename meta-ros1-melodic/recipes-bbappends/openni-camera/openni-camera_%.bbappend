# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[openni-camera] ?= "Depends on unavailable UNRESOLVED-libopenni-dev"

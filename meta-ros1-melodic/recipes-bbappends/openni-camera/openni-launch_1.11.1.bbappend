# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[openni-launch] ?= "depends on openni-camera which depends on unavailable UNRESOLVED-libopenni-dev"

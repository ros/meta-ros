# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[ifopt] ?= "Depends on unavailable UNRESOLVED-coinor-libipopt-dev"

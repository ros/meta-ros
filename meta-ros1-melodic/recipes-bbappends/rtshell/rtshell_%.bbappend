# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[rtshell] ?= "Depends on unavailable UNRESOLVED-python-omniorb"

# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[husky-robot] ?= "Depends on husky-bringup which depend on unavailable UNRESOLVED-python-scipy"

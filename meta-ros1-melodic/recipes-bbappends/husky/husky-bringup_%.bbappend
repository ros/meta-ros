# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[husky-bringup] ?= "Depends on unavailable UNRESOLVED-python-scipy"

# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[husky-base] ?= "Depends on husky-control which depends on multimaster-launch which depends on master-discovery-fkie which depends on unavailable UNRESOLVED-python-avahi"

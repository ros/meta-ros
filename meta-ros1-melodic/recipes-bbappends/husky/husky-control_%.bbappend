# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[husky-control] ?= "Depends on multimaster-launch which depends on master-discovery-fkie which depends on unavailable UNRESOLVED-python-avahi"

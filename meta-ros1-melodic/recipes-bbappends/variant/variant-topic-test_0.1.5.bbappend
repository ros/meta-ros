# Copyright (c) 2019 LG Electronics, Inc.

# Missing license version in package.xml maps it to invalid LGPL-2
# https://github.com/ANYbotics/variant-release/issues/1
LICENSE = "LGPL-3.0+"

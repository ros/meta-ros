# Copyright (c) 2020 LG Electronics, Inc.

# lex-common is just headers/staticlib files and PN is empty, so it wasn't created
ROS_EXEC_DEPENDS_remove = "lex-common"

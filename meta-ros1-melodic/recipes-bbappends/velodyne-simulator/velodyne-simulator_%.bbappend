# Copyright (c) 2020 LG Electronics, Inc.

# Depends on velodyne-gazebo-plugins with this restriction:
inherit features_check
REQUIRED_DISTRO_FEATURES = "ros-gazebo"

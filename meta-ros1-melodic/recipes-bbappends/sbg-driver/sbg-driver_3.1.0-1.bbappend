# Copyright (c) 2021 LG Electronics, Inc.

ROS_BUILD_DEPENDS += "tf2-ros nav-msgs tf2-geometry-msgs"

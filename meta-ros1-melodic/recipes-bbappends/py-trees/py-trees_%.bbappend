# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[py-trees] ?= "Rdepends on unavailable UNRESOLVED-python-pydot"

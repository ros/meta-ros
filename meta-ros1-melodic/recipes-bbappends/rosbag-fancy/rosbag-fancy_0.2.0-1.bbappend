# Copyright (c) 2020 LG Electronics, Inc.

# rosbag-fancy/0.2.0-1-r0/git/src/main.cpp:11:10: fatal error: std_srvs/Trigger.h: No such file or directory
DEPENDS += "std-srvs"

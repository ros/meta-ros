# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[master-discovery-fkie] ?= "Depends on unavailable UNRESOLVED-python-avahi"

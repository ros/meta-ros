# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[iirob-filters] ?= "It has a dependency on rosparam_handler for which there isn't an entry in melodic-cache.yaml nor base.yaml nor python.yaml nor ruby.yaml; it is not used by any other ROS 1 package."

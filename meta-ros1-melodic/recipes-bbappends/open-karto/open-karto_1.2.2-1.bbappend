# Copyright (c) 2019-2020 LG Electronics, Inc.

# Missing license version in package.xml
LICENSE = "LGPL-3.0"

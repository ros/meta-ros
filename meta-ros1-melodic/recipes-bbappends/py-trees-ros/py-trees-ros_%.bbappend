# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[py-trees-ros] ?= "Rdepends on unavailable UNRESOLVED-python-termcolor"

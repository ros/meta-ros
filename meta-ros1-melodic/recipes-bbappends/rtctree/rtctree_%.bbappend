# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[rtctree] ?= "Depends on unavailable UNRESOLVED-python-omniorb"

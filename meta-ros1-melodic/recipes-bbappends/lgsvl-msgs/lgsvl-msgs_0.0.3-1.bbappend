# Copyright (c) 2020 LG Electronics, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    ${PYTHON_PN}-catkin-pkg-native \
    ${PYTHON_PN}-empy-native \
"

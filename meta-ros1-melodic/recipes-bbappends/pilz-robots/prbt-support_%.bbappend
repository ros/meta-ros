# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[prbt-support] ?= "Depends on canopen-motor-node which depends on unavailable UNRESOLVED-muparser"

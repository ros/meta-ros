# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[prbt-hardware-support] ?= "Depends on pilz-utils which depends on unavailable clang-tidy"

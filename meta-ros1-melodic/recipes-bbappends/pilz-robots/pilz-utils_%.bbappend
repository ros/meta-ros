# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[pilz-utils] ?= "Depends on unavailable clang-tidy"

# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[canopen-motor-node] ?= "Depends on unavailable UNRESOLVED-muparser"

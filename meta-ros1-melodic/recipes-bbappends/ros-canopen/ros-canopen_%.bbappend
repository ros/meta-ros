# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[ros-canopen] ?= "Depends on canopen-motor-node which depends on unavailable UNRESOLVED-muparser"

# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[multimaster-launch] ?= "Depends on master-discovery-fkie which depends on unavailable UNRESOLVED-python-avahi"

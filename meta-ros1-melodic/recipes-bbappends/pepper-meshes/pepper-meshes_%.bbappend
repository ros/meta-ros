# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[pepper-meshes] ?= "Depends on unavailable UNRESOLVED-java"

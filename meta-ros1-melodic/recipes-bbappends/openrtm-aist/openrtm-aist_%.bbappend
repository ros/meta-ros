# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[openrtm-aist] ?= "Depends on unavailable UNRESOLVED-omniorb"

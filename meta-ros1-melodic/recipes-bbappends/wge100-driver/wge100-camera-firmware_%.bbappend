# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[wge100-camera-firmware] ?= "Depends on unavailable UNRESOLVED-gforth"

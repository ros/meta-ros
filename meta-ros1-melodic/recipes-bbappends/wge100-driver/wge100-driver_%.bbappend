# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[wge100-driver] ?= "Depends on wge100-camera-firmware which depends on unavailable UNRESOLVED-gforth"

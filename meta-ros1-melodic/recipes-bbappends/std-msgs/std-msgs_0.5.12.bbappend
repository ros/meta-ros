# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILD_DEPENDS += " \
    ${PYTHON_PN}-pyyaml-native \
"

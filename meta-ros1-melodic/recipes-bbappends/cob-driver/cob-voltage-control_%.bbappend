# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[cob-voltage-control] ?= "Rdepends on unavailable UNRESOLVED-python-tk"

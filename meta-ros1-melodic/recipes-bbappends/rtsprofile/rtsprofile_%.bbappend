# Copyright (c) 2020 LG Electronics, Inc.

PNBLACKLIST[rtsprofile] ?= "Depends on unavailable UNRESOLVED-python-omniorb"

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "Catkin wrapper for the official ARSDK from Parrot"
AUTHOR = "Mani Monajjemi <mmonajje@sfu.ca>"
ROS_AUTHOR = "Parrot S.A. <unknow@parrot.com>"
HOMEPAGE = "http://wiki.ros.org/parrot_arsdk"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "parrot_arsdk"
ROS_BPN = "parrot_arsdk"

ROS_BUILD_DEPENDS = " \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libavahi-client-dev} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libavahi-core-dev} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_nasm} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_yasm} \
    autoconf \
    automake \
    curl \
    ffmpeg \
    libtool \
    ncurses \
    unzip \
    zlib \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = ""

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/AutonomyLab/parrot_arsdk-release/archive/release/melodic/parrot_arsdk/3.14.1-0.tar.gz
ROS_BRANCH ?= "branch=release/melodic/parrot_arsdk"
SRC_URI = "git://github.com/AutonomyLab/parrot_arsdk-release;${ROS_BRANCH};protocol=https"
SRCREV = "14e5cf04628342ce9135de19301baf6a580d2c6f"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

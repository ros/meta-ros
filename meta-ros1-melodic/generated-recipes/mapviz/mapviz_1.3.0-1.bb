# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "mapviz"
AUTHOR = "Marc Alban <malban@swri.org>"
ROS_AUTHOR = "Marc Alban"
HOMEPAGE = "https://github.com/swri-robotics/mapviz"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "mapviz"
ROS_BPN = "mapviz"

ROS_BUILD_DEPENDS = " \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libglew-dev} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libxi-dev} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libxmu-dev} \
    cv-bridge \
    freeglut \
    image-transport \
    libqt-opengl-rosdev \
    libqt-rosdev \
    marti-common-msgs \
    message-generation \
    pluginlib \
    rosapi \
    roscpp \
    rqt-gui \
    rqt-gui-cpp \
    std-srvs \
    swri-transform-util \
    swri-yaml-util \
    tf \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
    pkgconfig-native \
    qt-qmake-native \
"

ROS_EXPORT_DEPENDS = " \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libglew-dev} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libxi-dev} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libxmu-dev} \
    cv-bridge \
    freeglut \
    image-transport \
    marti-common-msgs \
    pluginlib \
    rosapi \
    roscpp \
    rqt-gui \
    rqt-gui-cpp \
    std-srvs \
    swri-transform-util \
    swri-yaml-util \
    tf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libglew-dev} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libxi-dev} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libxmu-dev} \
    cv-bridge \
    freeglut \
    image-transport \
    libqt-core \
    libqt-opengl \
    marti-common-msgs \
    message-runtime \
    pluginlib \
    rosapi \
    roscpp \
    rqt-gui \
    rqt-gui-cpp \
    std-srvs \
    swri-transform-util \
    swri-yaml-util \
    tf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/swri-robotics-gbp/mapviz-release/archive/release/melodic/mapviz/1.3.0-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/mapviz"
SRC_URI = "git://github.com/swri-robotics-gbp/mapviz-release;${ROS_BRANCH};protocol=https"
SRCREV = "8e39ca8b4b0a05512a741c0e15492b61b6aadba5"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

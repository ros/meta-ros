# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "The radial_menu_example package"
AUTHOR = "Yoshito Okada <okada@rm.is.tohoku.ac.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=2c00b8d2854109dbebef7818b4dae1e2"

ROS_CN = "radial_menu_ros"
ROS_BPN = "radial_menu_example"

ROS_BUILD_DEPENDS = " \
    joy \
    message-filters \
    radial-menu-backend \
    radial-menu-model \
    radial-menu-msgs \
    radial-menu-rviz \
    roscpp \
    roslaunch \
    rviz \
    sensor-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    joy \
    message-filters \
    radial-menu-backend \
    radial-menu-model \
    radial-menu-msgs \
    radial-menu-rviz \
    roscpp \
    roslaunch \
    rviz \
    sensor-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    joy \
    message-filters \
    radial-menu-backend \
    radial-menu-model \
    radial-menu-msgs \
    radial-menu-rviz \
    roscpp \
    roslaunch \
    rviz \
    sensor-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/yoshito-n-students/radial_menu_ros-release/archive/release/melodic/radial_menu_example/0.4.1-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/radial_menu_example"
SRC_URI = "git://github.com/yoshito-n-students/radial_menu_ros-release;${ROS_BRANCH};protocol=https"
SRCREV = "f9146f802f106a8c7bb348dd0a3b2f753183f59c"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

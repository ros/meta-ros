# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "The Move Base Flex (MBF) recovery behavior moves the robot back for specified length.         It also checks the costmap for a possible collision behind the robot while moving and         stops the robot if necessary."
AUTHOR = "Sebastian Pütz <spuetz@uos.de>"
ROS_AUTHOR = "Sebastian Pütz <spuetz@uos.de>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=ba717dc718040ac1636f383eca24f11f"

ROS_CN = "mbf_recovery_behaviors"
ROS_BPN = "moveback_recovery"

ROS_BUILD_DEPENDS = " \
    base-local-planner \
    costmap-2d \
    mbf-costmap-core \
    mbf-msgs \
    pluginlib \
    roscpp \
    tf2-geometry-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    base-local-planner \
    costmap-2d \
    mbf-costmap-core \
    mbf-msgs \
    pluginlib \
    roscpp \
    tf2-geometry-msgs \
    tf2-ros \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/uos-gbp/mbf_recovery_behaviors/archive/release/melodic/moveback_recovery/0.1.0-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/moveback_recovery"
SRC_URI = "git://github.com/uos-gbp/mbf_recovery_behaviors;${ROS_BRANCH};protocol=https"
SRCREV = "ed038027e91fd5bb753990a179db6dc9fa8ac6de"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

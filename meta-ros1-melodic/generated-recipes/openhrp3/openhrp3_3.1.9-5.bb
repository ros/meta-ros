# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "<p>This package does not only wrap <a href="http://www.openrtp.jp/openhrp3/en/index.html">OpenHRP3</a> but actually provides the built artifact from the code from its <a href="https://openrtp.jp/svn/hrg/openhrp">mainstream repository</a>. Being ROS-agnostic by itself, you can also use this via ROS together with the packages in <a href="http://www.ros.org/wiki/rtmros_common">rtmros_common</a> that bridge between two framework.</p>    <p><i>OpenHRP3 (Open Architecture Human-centered Robotics Platform version 3) is an integrated software platform for robot simulations and software developments. It allows the users to inspect an original robot model and control program by dynamics simulation. In addition, OpenHRP3 provides various software components and calculation libraries that can be used for robotics related software developments</i> (<a href="http://www.openrtp.jp/openhrp3/en/about.html">excerpts from here</a>). </p>    <p>The package version number is synchronized to that of mainstream, based on <a href="http://code.google.com/p/rtm-ros-robotics/issues/detail?id=165#c5">this decision</a>.</p>"
AUTHOR = "Kei Okada <k-okada@jsk.t.u-tokyo.ac.jp>"
ROS_AUTHOR = "AIST"
HOMEPAGE = "https://openrtp.jp/svn/hrg/openhrp/"
SECTION = "devel"
LICENSE = "EPL"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=b1456987590b6d6fb15d36f398651b8b"

ROS_CN = "openhrp3"
ROS_BPN = "openhrp3"

ROS_BUILD_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-atlas} \
    ${ROS_UNRESOLVED_DEP-f2c} \
    ${ROS_UNRESOLVED_DEP-python-omniorb} \
    boost \
    collada-dom \
    doxygen \
    jpeg \
    libeigen \
    libpng \
    libxml2 \
    openrtm-aist \
"

ROS_BUILDTOOL_DEPENDS = " \
    cmake-native \
    pkgconfig-native \
"

ROS_EXPORT_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-atlas} \
    ${ROS_UNRESOLVED_DEP-f2c} \
    ${ROS_UNRESOLVED_DEP-python-omniorb} \
    boost \
    collada-dom \
    jpeg \
    libeigen \
    libpng \
    libxml2 \
    openrtm-aist \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-atlas} \
    ${ROS_UNRESOLVED_DEP-f2c} \
    ${ROS_UNRESOLVED_DEP-python-omniorb} \
    boost \
    collada-dom \
    jpeg \
    libeigen \
    libpng \
    libxml2 \
    openrtm-aist \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/tork-a/openhrp3-release/archive/release/melodic/openhrp3/3.1.9-5.tar.gz
ROS_BRANCH ?= "branch=release/melodic/openhrp3"
SRC_URI = "git://github.com/tork-a/openhrp3-release;${ROS_BRANCH};protocol=https"
SRCREV = "3faf61d3277512d7c159c2dc2049c9efadebb038"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

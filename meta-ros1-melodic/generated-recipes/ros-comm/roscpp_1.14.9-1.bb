# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "roscpp is a C++ implementation of ROS. It provides     a <a href="http://wiki.ros.org/Client%20Libraries">client     library</a> that enables C++ programmers to quickly interface with     ROS <a href="http://ros.org/wiki/Topics">Topics</a>,     <a href="http://ros.org/wiki/Services">Services</a>,     and <a href="http://ros.org/wiki/Parameter Server">Parameters</a>.      roscpp is the most widely used ROS client library and is designed to     be the high-performance library for ROS."
AUTHOR = "Dirk Thomas <dthomas@osrfoundation.org>"
ROS_AUTHOR = "Morgan Quigley"
HOMEPAGE = "http://ros.org/wiki/roscpp"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=16;endline=16;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "ros_comm"
ROS_BPN = "roscpp"

ROS_BUILD_DEPENDS = " \
    cpp-common \
    message-generation \
    pkgconfig \
    rosconsole \
    roscpp-serialization \
    roscpp-traits \
    rosgraph-msgs \
    roslang \
    rostime \
    std-msgs \
    xmlrpcpp \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    cpp-common \
    message-runtime \
    rosconsole \
    roscpp-serialization \
    roscpp-traits \
    rosgraph-msgs \
    rostime \
    std-msgs \
    xmlrpcpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    cpp-common \
    message-runtime \
    rosconsole \
    roscpp-serialization \
    roscpp-traits \
    rosgraph-msgs \
    rostime \
    std-msgs \
    xmlrpcpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros-gbp/ros_comm-release/archive/release/melodic/roscpp/1.14.9-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/roscpp"
SRC_URI = "git://github.com/ros-gbp/ros_comm-release;${ROS_BRANCH};protocol=https"
SRCREV = "1e4e0fdb125c2489d885655f86988671f350f781"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "Plays a pre-recorded motion on a robot"
AUTHOR = "Victor Lopez <victor.lopez@pal-robotics.com>"
ROS_AUTHOR = "Paul Mathieu <paul.mathieu@pal-robotics.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "play_motion"
ROS_BPN = "play_motion"

ROS_BUILD_DEPENDS = " \
    actionlib \
    control-msgs \
    controller-manager-msgs \
    diagnostic-msgs \
    diagnostic-updater \
    moveit-ros-planning-interface \
    play-motion-msgs \
    roscpp \
    sensor-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    actionlib \
    control-msgs \
    controller-manager-msgs \
    diagnostic-msgs \
    diagnostic-updater \
    moveit-ros-planning-interface \
    play-motion-msgs \
    roscpp \
    sensor-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    actionlib \
    control-msgs \
    controller-manager-msgs \
    diagnostic-msgs \
    diagnostic-updater \
    moveit-ros-planning-interface \
    play-motion-msgs \
    roscpp \
    sensor-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    controller-manager \
    hardware-interface \
    joint-state-controller \
    joint-trajectory-controller \
    position-controllers \
    robot-state-publisher \
    rostest \
    xacro \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/pal-gbp/play_motion-release2/archive/release/melodic/play_motion/0.4.8-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/play_motion"
SRC_URI = "git://github.com/pal-gbp/play_motion-release2;${ROS_BRANCH};protocol=https"
SRCREV = "9ae76ce5eaf67c27fdc08d4f35a583f5c6b97e59"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

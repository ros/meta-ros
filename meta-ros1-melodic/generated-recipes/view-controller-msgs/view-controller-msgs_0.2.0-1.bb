# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "Messages for (camera) view controllers"
AUTHOR = "Evan Flynn <evanflynn.msu@gmail.com>"
ROS_AUTHOR = "Adam Leeper <adamleeper@gmail.com>"
HOMEPAGE = "http://ros.org/wiki/view_controller_msgs"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "view_controller_msgs"
ROS_BPN = "view_controller_msgs"

ROS_BUILD_DEPENDS = " \
    genmsg \
    geometry-msgs \
    message-generation \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    geometry-msgs \
    message-runtime \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    geometry-msgs \
    message-runtime \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros-gbp/view_controller_msgs-release/archive/release/melodic/view_controller_msgs/0.2.0-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/view_controller_msgs"
SRC_URI = "git://github.com/ros-gbp/view_controller_msgs-release;${ROS_BRANCH};protocol=https"
SRCREV = "ad8efe83f69d55b141d288b006076a9ee184031d"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

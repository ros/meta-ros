# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "ROS driver for LP-Research OpenZen"
AUTHOR = "Feng <lxf@alubi.cn>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "MIT & Boost Software License & LGPLv3 & BSD"
LICENSE = "MIT & BSL-1.0 & LGPL-3.0-only & BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=17aa8a6fb4ebd2ec377bc14aaa9ab8d7"

ROS_CN = "openzen_sensor"
ROS_BPN = "openzen_sensor"

ROS_BUILD_DEPENDS = " \
    roscpp \
    sensor-msgs \
    std-msgs \
    std-srvs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    roscpp \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf \
    topic-tools \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    roscpp \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf \
    topic-tools \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    roslaunch \
    rostest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/lp-research/openzen_sensor-release/archive/release/melodic/openzen_sensor/1.0.1-2.tar.gz
ROS_BRANCH ?= "branch=release/melodic/openzen_sensor"
SRC_URI = "git://github.com/lp-research/openzen_sensor-release;${ROS_BRANCH};protocol=https"
SRCREV = "057e6f456fa8ded11b0347bb30b276cea430d2bf"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

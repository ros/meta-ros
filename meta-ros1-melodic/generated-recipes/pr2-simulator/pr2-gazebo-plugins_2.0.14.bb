# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "Gazebo Plugins for various PR2-specific sensors and actuators on the robot."
AUTHOR = "ROS Orphaned Package Maintainers <ros-orphaned-packages@googlegroups.com>"
ROS_AUTHOR = "John Hsu"
HOMEPAGE = "http://ros.org/wiki/pr2_gazebo_plugins"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "pr2_simulator"
ROS_BPN = "pr2_gazebo_plugins"

ROS_BUILD_DEPENDS = " \
    angles \
    cv-bridge \
    diagnostic-msgs \
    diagnostic-updater \
    gazebo-msgs \
    gazebo-plugins \
    geometry-msgs \
    image-transport \
    message-generation \
    message-runtime \
    nav-msgs \
    orocos-kdl \
    polled-camera \
    pr2-controller-manager \
    pr2-hardware-interface \
    pr2-mechanism-model \
    pr2-msgs \
    roscpp \
    rospy \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf \
    urdf \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    angles \
    cv-bridge \
    diagnostic-msgs \
    diagnostic-updater \
    gazebo-msgs \
    gazebo-plugins \
    gazebo-ros \
    geometry-msgs \
    image-transport \
    message-generation \
    message-runtime \
    nav-msgs \
    orocos-kdl \
    polled-camera \
    pr2-controller-manager \
    pr2-hardware-interface \
    pr2-mechanism-model \
    pr2-msgs \
    roscpp \
    rospy \
    sensor-msgs \
    std-msgs \
    tf \
    urdf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    angles \
    cv-bridge \
    diagnostic-msgs \
    diagnostic-updater \
    gazebo-msgs \
    gazebo-plugins \
    gazebo-ros \
    geometry-msgs \
    image-transport \
    message-generation \
    message-runtime \
    nav-msgs \
    orocos-kdl \
    polled-camera \
    pr2-controller-manager \
    pr2-hardware-interface \
    pr2-mechanism-model \
    pr2-msgs \
    roscpp \
    rospy \
    sensor-msgs \
    std-msgs \
    tf \
    urdf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/pr2-gbp/pr2_simulator-release/archive/release/melodic/pr2_gazebo_plugins/2.0.14-0.tar.gz
ROS_BRANCH ?= "branch=release/melodic/pr2_gazebo_plugins"
SRC_URI = "git://github.com/pr2-gbp/pr2_simulator-release;${ROS_BRANCH};protocol=https"
SRCREV = "f95bf99aec97b42d7c2964026dbe15cb54ede71e"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "The seed_r7_ros_controller package"
AUTHOR = "hi.kondo <hi.kondo@thk.co.jp>"
ROS_AUTHOR = "Yohei Kakiuchi"
HOMEPAGE = "http://ros.org/wiki/"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "seed_r7_ros_pkg"
ROS_BPN = "seed_r7_ros_controller"

ROS_BUILD_DEPENDS = " \
    angles \
    control-msgs \
    control-toolbox \
    controller-manager \
    geometry-msgs \
    hardware-interface \
    joint-limits-interface \
    joint-state-controller \
    joint-trajectory-controller \
    message-generation \
    move-base-msgs \
    nav-msgs \
    pluginlib \
    realtime-tools \
    roscpp \
    rostest \
    seed-r7-description \
    seed-smartactuator-sdk \
    sensor-msgs \
    std-msgs \
    tf \
    trajectory-msgs \
    transmission-interface \
    urdf \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    angles \
    control-msgs \
    control-toolbox \
    controller-manager \
    geometry-msgs \
    hardware-interface \
    joint-limits-interface \
    joint-state-controller \
    joint-trajectory-controller \
    message-generation \
    move-base-msgs \
    nav-msgs \
    pluginlib \
    realtime-tools \
    roscpp \
    rostest \
    seed-r7-description \
    seed-smartactuator-sdk \
    sensor-msgs \
    std-msgs \
    tf \
    trajectory-msgs \
    transmission-interface \
    urdf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    angles \
    control-msgs \
    control-toolbox \
    controller-manager \
    geometry-msgs \
    hardware-interface \
    joint-limits-interface \
    joint-state-controller \
    joint-trajectory-controller \
    message-generation \
    move-base-msgs \
    nav-msgs \
    pluginlib \
    realtime-tools \
    roscpp \
    rostest \
    seed-r7-description \
    seed-smartactuator-sdk \
    sensor-msgs \
    std-msgs \
    tf \
    trajectory-msgs \
    transmission-interface \
    urdf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/seed-solutions/seed_r7_ros_pkg-release/archive/release/melodic/seed_r7_ros_controller/0.3.3-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/seed_r7_ros_controller"
SRC_URI = "git://github.com/seed-solutions/seed_r7_ros_pkg-release;${ROS_BRANCH};protocol=https"
SRCREV = "54e1c9728ddf361d84426ae725897ab6176161ae"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "The robotont_gazebo package"
AUTHOR = "Veiko Vunder <veiko.vunder@ut.ee>"
HOMEPAGE = "https://wiki.ros.org/robotont"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=3dce4ba60d7e51ec64f3c3dc18672dd3"

ROS_CN = "robotont_gazebo"
ROS_BPN = "robotont_gazebo"

ROS_BUILD_DEPENDS = " \
    joy \
    nav-msgs \
    roscpp \
    rospy \
    std-msgs \
    tf \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    gazebo-ros \
    gazebo-ros-pkgs \
    joy \
    nav-msgs \
    robotont-description \
    robotont-nuc-description \
    roscpp \
    rospy \
    std-msgs \
    tf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/robotont-release/robotont_gazebo-release/archive/release/melodic/robotont_gazebo/0.0.2-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/robotont_gazebo"
SRC_URI = "git://github.com/robotont-release/robotont_gazebo-release;${ROS_BRANCH};protocol=https"
SRCREV = "9eb85fde1a2e24ab1fa5a2640d17a287e650395d"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

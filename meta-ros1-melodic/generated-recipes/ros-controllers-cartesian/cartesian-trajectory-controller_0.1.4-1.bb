# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "A Cartesian trajectory controller with multiple hardware interface support"
AUTHOR = "Stefan Scherzinger <scherzin@fzi.de>"
HOMEPAGE = "http://wiki.ros.org/cartesian_trajectory_controller"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=2c00b8d2854109dbebef7818b4dae1e2"

ROS_CN = "ros_controllers_cartesian"
ROS_BPN = "cartesian_trajectory_controller"

ROS_BUILD_DEPENDS = " \
    cartesian-interface \
    cartesian-trajectory-interpolation \
    controller-manager \
    hardware-interface \
    kdl-parser \
    pluginlib \
    roscpp \
    rospy \
    speed-scaling-interface \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    cartesian-interface \
    cartesian-trajectory-interpolation \
    controller-manager \
    hardware-interface \
    kdl-parser \
    pluginlib \
    roscpp \
    rospy \
    speed-scaling-interface \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    cartesian-interface \
    controller-interface \
    controller-manager \
    hardware-interface \
    roscpp \
    rospy \
    speed-scaling-interface \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    actionlib \
    actionlib-msgs \
    control-msgs \
    controller-manager-msgs \
    joint-state-controller \
    joint-trajectory-controller \
    robot-state-publisher \
    ros-control-boilerplate \
    rostest \
    trajectory-msgs \
    xacro \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/UniversalRobots/Universal_Robots_ROS_controllers_cartesian-release/archive/release/melodic/cartesian_trajectory_controller/0.1.4-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/cartesian_trajectory_controller"
SRC_URI = "git://github.com/UniversalRobots/Universal_Robots_ROS_controllers_cartesian-release;${ROS_BRANCH};protocol=https"
SRCREV = "74d605d4b66b44bc9a5a13333bb66d166f48d91f"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

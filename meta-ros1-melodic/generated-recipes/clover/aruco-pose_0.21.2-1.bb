# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "Positioning with ArUco markers"
AUTHOR = "Oleg Kalachev <okalachev@gmail.com>"
ROS_AUTHOR = "Oleg Kalachev <okalachev@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "clover"
ROS_BPN = "aruco_pose"

ROS_BUILD_DEPENDS = " \
    cv-bridge \
    dynamic-reconfigure \
    geometry-msgs \
    image-transport \
    message-generation \
    message-runtime \
    nodelet \
    roscpp \
    rostest \
    sensor-msgs \
    std-msgs \
    tf \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    cv-bridge \
    dynamic-reconfigure \
    geometry-msgs \
    image-transport \
    message-generation \
    message-runtime \
    nodelet \
    roscpp \
    rostest \
    sensor-msgs \
    std-msgs \
    tf \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    cv-bridge \
    dynamic-reconfigure \
    geometry-msgs \
    image-transport \
    message-generation \
    message-runtime \
    nodelet \
    roscpp \
    rostest \
    sensor-msgs \
    std-msgs \
    tf \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    image-publisher \
    ros-pytest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/CopterExpress/clover-release/archive/release/melodic/aruco_pose/0.21.2-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/aruco_pose"
SRC_URI = "git://github.com/CopterExpress/clover-release;${ROS_BRANCH};protocol=https"
SRCREV = "7c3ec3e1eb1182dcc37cd9877b9f6651462cf28a"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

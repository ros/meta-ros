# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "Provides teleoperation using multi-key input for Turtlesim/Turtlebot3."
AUTHOR = "EngHyu <roomedia@naver.com>"
ROS_AUTHOR = "EngHyu <roomedia@naver.com>"
HOMEPAGE = "https://wiki.ros.org/turtle_teleop_multi_key"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "MIT License"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=e093dbacd8b861c0bd410cc6f33e06c4"

ROS_CN = "turtle_teleop_multi_key"
ROS_BPN = "turtle_teleop_multi_key"

ROS_BUILD_DEPENDS = " \
    geometry-msgs \
    rospy \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    geometry-msgs \
    rospy \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    geometry-msgs \
    rospy \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/EngHyu/turtle_teleop_multi_key-release/archive/release/melodic/turtle_teleop_multi_key/0.0.4-3.tar.gz
ROS_BRANCH ?= "branch=release/melodic/turtle_teleop_multi_key"
SRC_URI = "git://github.com/EngHyu/turtle_teleop_multi_key-release;${ROS_BRANCH};protocol=https"
SRCREV = "275d415778a377f910cdc60ffbc67f5adf18d30d"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

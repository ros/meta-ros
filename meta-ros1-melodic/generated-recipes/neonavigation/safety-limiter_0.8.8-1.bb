# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "Motion limiter package for collision prevention"
AUTHOR = "Atsushi Watanabe <atsushi.w@ieee.org>"
ROS_AUTHOR = "Atsushi Watanabe <atsushi.w@ieee.org>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "neonavigation"
ROS_BPN = "safety_limiter"

ROS_BUILD_DEPENDS = " \
    diagnostic-updater \
    geometry-msgs \
    libeigen \
    neonavigation-common \
    pcl \
    pcl-conversions \
    pcl-ros \
    roscpp \
    safety-limiter-msgs \
    sensor-msgs \
    std-msgs \
    tf2-ros \
    tf2-sensor-msgs \
    xmlrpcpp \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    diagnostic-updater \
    geometry-msgs \
    libeigen \
    neonavigation-common \
    pcl-conversions \
    pcl-ros \
    roscpp \
    safety-limiter-msgs \
    sensor-msgs \
    std-msgs \
    tf2-ros \
    tf2-sensor-msgs \
    xmlrpcpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    diagnostic-updater \
    geometry-msgs \
    libeigen \
    neonavigation-common \
    pcl \
    pcl-conversions \
    pcl-ros \
    roscpp \
    safety-limiter-msgs \
    sensor-msgs \
    std-msgs \
    tf2-ros \
    tf2-sensor-msgs \
    xmlrpcpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    nav-msgs \
    roslint \
    rostest \
    tf2-geometry-msgs \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/at-wat/neonavigation-release/archive/release/melodic/safety_limiter/0.8.8-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/safety_limiter"
SRC_URI = "git://github.com/at-wat/neonavigation-release;${ROS_BRANCH};protocol=https"
SRCREV = "70faefe530b37a82951db78e719706029a70e65b"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

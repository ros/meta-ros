# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "The play_motion_builder package, a node to handle the creation of new motions for play_motion."
AUTHOR = "davidfernandez <david.fernandez@pal-robotics.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "LGPL-3.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=a8c41fd6b72c7d3bd996ba4f3d34a6ae"

ROS_CN = "play_motion_builder"
ROS_BPN = "play_motion_builder"

ROS_BUILD_DEPENDS = " \
    actionlib \
    play-motion-builder-msgs \
    play-motion-msgs \
    roscpp \
    sensor-msgs \
    yaml-cpp \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    actionlib \
    play-motion-builder-msgs \
    play-motion-msgs \
    roscpp \
    sensor-msgs \
    yaml-cpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    actionlib \
    play-motion-builder-msgs \
    play-motion-msgs \
    roscpp \
    sensor-msgs \
    yaml-cpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    rostest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/pal-robotics/play_motion_builder-release/archive/release/melodic/play_motion_builder/1.0.2-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/play_motion_builder"
SRC_URI = "git://github.com/pal-robotics/play_motion_builder-release;${ROS_BRANCH};protocol=https"
SRCREV = "b7ac117229e52fd640536cb252af1164d7875f7b"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

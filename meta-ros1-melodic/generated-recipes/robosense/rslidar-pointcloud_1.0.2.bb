# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "Point cloud conversions for rslidar 3D LIDARs."
AUTHOR = "Abraham Monrroy <abrahammonrroy@yahoo.com>"
ROS_AUTHOR = "Tony Zhang <tony.zhang@robosense.cn>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=01c2bc31767ccb3a68e12f02612b2a97"

ROS_CN = "robosense"
ROS_BPN = "rslidar_pointcloud"

ROS_BUILD_DEPENDS = " \
    angles \
    dynamic-reconfigure \
    nodelet \
    pcl-conversions \
    pcl-ros \
    pluginlib \
    roscpp \
    roslaunch \
    roslib \
    rostest \
    rslidar-driver \
    rslidar-msgs \
    sensor-msgs \
    tf \
    tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    angles \
    dynamic-reconfigure \
    nodelet \
    pcl-ros \
    pluginlib \
    roscpp \
    roslib \
    rslidar-driver \
    rslidar-msgs \
    sensor-msgs \
    tf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    angles \
    dynamic-reconfigure \
    nodelet \
    pcl-ros \
    pluginlib \
    roscpp \
    roslib \
    rslidar-driver \
    rslidar-msgs \
    sensor-msgs \
    tf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/CPFL/robosense-release/archive/release/melodic/rslidar_pointcloud/1.0.2-0.tar.gz
ROS_BRANCH ?= "branch=release/melodic/rslidar_pointcloud"
SRC_URI = "git://github.com/CPFL/robosense-release;${ROS_BRANCH};protocol=https"
SRCREV = "7dbdafb02e7f0637e1305b3c7a806b707b5f62c1"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

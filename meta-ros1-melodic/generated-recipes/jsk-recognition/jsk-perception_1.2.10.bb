# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "ROS nodes and nodelets for 2-D image perception."
AUTHOR = "Kei Okada <k-okada@jsk.t.u-tokyo.ac.jp>"
ROS_AUTHOR = "Manabu Saito"
HOMEPAGE = "http://jsk-docs.readthedocs.io/en/latest/jsk_recognition/doc/jsk_perception"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "jsk_recognition"
ROS_BPN = "jsk_perception"

ROS_BUILD_DEPENDS = " \
    angles \
    cmake-modules \
    cv-bridge \
    dynamic-reconfigure \
    geometry-msgs \
    git \
    image-geometry \
    image-transport \
    image-view2 \
    jsk-data \
    jsk-recognition-msgs \
    jsk-recognition-utils \
    jsk-topic-tools \
    libcmt \
    libeigen \
    message-generation \
    mk \
    nodelet \
    opencv-apps \
    pcl-ros \
    posedetection-msgs \
    robot-self-filter \
    roscpp \
    roseus \
    rospack \
    sensor-msgs \
    std-msgs \
    tf \
    yaml-cpp \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    ${PYTHON_PN}-pyyaml \
    ${ROS_UNRESOLVED_DEP-python-chainer-pip} \
    ${ROS_UNRESOLVED_DEP-python-chainercv-pip} \
    ${ROS_UNRESOLVED_DEP-python-dlib} \
    ${ROS_UNRESOLVED_DEP-python-fcn-pip} \
    ${ROS_UNRESOLVED_DEP-python-h5py} \
    ${ROS_UNRESOLVED_DEP-python-sklearn} \
    angles \
    cv-bridge \
    dynamic-reconfigure \
    geometry-msgs \
    image-geometry \
    image-transport \
    image-view \
    image-view2 \
    imagesift \
    jsk-data \
    jsk-gui-msgs \
    jsk-recognition-msgs \
    jsk-recognition-utils \
    jsk-topic-tools \
    leveldb \
    libcmt \
    libeigen \
    message-runtime \
    mk \
    nodelet \
    opencv-apps \
    openni2-launch \
    pcl-ros \
    posedetection-msgs \
    robot-self-filter \
    rosbag \
    roscpp \
    roseus \
    rospack \
    rospy \
    rostopic \
    rqt-gui \
    rviz \
    sensor-msgs \
    sound-play \
    std-msgs \
    tf \
    yaml-cpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ${PYTHON_PN}-pyyaml \
    ${ROS_UNRESOLVED_DEP-python-chainer-pip} \
    ${ROS_UNRESOLVED_DEP-python-chainercv-pip} \
    ${ROS_UNRESOLVED_DEP-python-dlib} \
    ${ROS_UNRESOLVED_DEP-python-fcn-pip} \
    ${ROS_UNRESOLVED_DEP-python-h5py} \
    ${ROS_UNRESOLVED_DEP-python-sklearn} \
    angles \
    cv-bridge \
    dynamic-reconfigure \
    geometry-msgs \
    image-geometry \
    image-transport \
    image-view \
    image-view2 \
    imagesift \
    jsk-data \
    jsk-gui-msgs \
    jsk-recognition-msgs \
    jsk-recognition-utils \
    jsk-topic-tools \
    leveldb \
    libcmt \
    libeigen \
    message-runtime \
    mk \
    nodelet \
    opencv-apps \
    openni2-launch \
    pcl-ros \
    posedetection-msgs \
    robot-self-filter \
    rosbag \
    roscpp \
    roseus \
    rospack \
    rospy \
    rostopic \
    rqt-gui \
    rviz \
    sensor-msgs \
    sound-play \
    std-msgs \
    tf \
    yaml-cpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    jsk-tools \
    roslaunch \
    roslint \
    rostest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/tork-a/jsk_recognition-release/archive/release/melodic/jsk_perception/1.2.10-0.tar.gz
ROS_BRANCH ?= "branch=release/melodic/jsk_perception"
SRC_URI = "git://github.com/tork-a/jsk_recognition-release;${ROS_BRANCH};protocol=https"
SRCREV = "fdf8ad98ac7d7cc0e25e1a03457f6916d3db9325"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "ROS nodelets for pointcloud perception."
AUTHOR = "Youhei Kakiuchi <youhei@jsk.t.u-tokyo.ac.jp>"
ROS_AUTHOR = "Yohei Kakiuchi <youhei@jsk.t.u-tokyo.ac.jp>"
HOMEPAGE = "http://jsk-docs.readthedocs.io/en/latest/jsk_recognition/doc/jsk_pcl_ros"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "jsk_recognition"
ROS_BPN = "jsk_pcl_ros"

ROS_BUILD_DEPENDS = " \
    cv-bridge \
    image-geometry \
    interactive-markers \
    jsk-data \
    jsk-pcl-ros-utils \
    jsk-recognition-utils \
    jsk-topic-tools \
    laser-assembler \
    moveit-ros-perception \
    octomap-server \
    pcl-msgs \
    pcl-ros \
    tf \
    tf-conversions \
    yaml-cpp \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    ${ROS_UNRESOLVED_PLATFORM_PKG_python-sklearn} \
    boost \
    checkerboard-detector \
    cv-bridge \
    diagnostic-msgs \
    diagnostic-updater \
    dynamic-reconfigure \
    eigen-conversions \
    geometry-msgs \
    image-geometry \
    image-transport \
    image-view2 \
    interactive-markers \
    jsk-data \
    jsk-footstep-msgs \
    jsk-interactive-marker \
    jsk-pcl-ros-utils \
    jsk-recognition-msgs \
    jsk-recognition-utils \
    jsk-topic-tools \
    kdl-conversions \
    kdl-parser \
    laser-assembler \
    moveit-core \
    moveit-ros-perception \
    nav-msgs \
    nodelet \
    octomap \
    octomap-server \
    openni-launch \
    openni2-launch \
    pcl-conversions \
    pcl-msgs \
    pcl-ros \
    resized-image-transport \
    robot-self-filter \
    rosboost-cfg \
    roscpp-tutorials \
    sensor-msgs \
    std-msgs \
    std-srvs \
    stereo-image-proc \
    stereo-msgs \
    tf \
    tf-conversions \
    tf2-ros \
    topic-tools \
    visualization-msgs \
    yaml-cpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ${ROS_UNRESOLVED_PLATFORM_PKG_python-sklearn} \
    boost \
    checkerboard-detector \
    cv-bridge \
    diagnostic-msgs \
    diagnostic-updater \
    dynamic-reconfigure \
    eigen-conversions \
    geometry-msgs \
    image-geometry \
    image-transport \
    image-view2 \
    interactive-markers \
    jsk-data \
    jsk-footstep-msgs \
    jsk-interactive-marker \
    jsk-pcl-ros-utils \
    jsk-recognition-msgs \
    jsk-recognition-utils \
    jsk-topic-tools \
    kdl-conversions \
    kdl-parser \
    laser-assembler \
    moveit-core \
    moveit-ros-perception \
    nav-msgs \
    nodelet \
    octomap \
    octomap-server \
    openni-launch \
    openni2-launch \
    pcl-conversions \
    pcl-msgs \
    pcl-ros \
    resized-image-transport \
    robot-self-filter \
    rosboost-cfg \
    roscpp-tutorials \
    sensor-msgs \
    std-msgs \
    std-srvs \
    stereo-image-proc \
    stereo-msgs \
    tf \
    tf-conversions \
    tf2-ros \
    topic-tools \
    visualization-msgs \
    yaml-cpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    jsk-perception \
    jsk-tools \
    roslaunch \
    rostest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/tork-a/jsk_recognition-release/archive/release/melodic/jsk_pcl_ros/1.2.10-0.tar.gz
ROS_BRANCH ?= "branch=release/melodic/jsk_pcl_ros"
SRC_URI = "git://github.com/tork-a/jsk_recognition-release;${ROS_BRANCH};protocol=https"
SRCREV = "3f9329d8b8d476b4feeb66cf0f07557c098e7af8"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "The omnibase_gazebo package"
AUTHOR = "Harshal Heshpande <hardesh1deshpande@gmail.com>"
ROS_AUTHOR = "Harshal Deshpande <hardesh1deshpande@gmail.com>"
HOMEPAGE = "https://erc-bpgc.github.io/omnibase/"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "omnibase"
ROS_BPN = "omnibase_gazebo"

ROS_BUILD_DEPENDS = " \
    effort-controllers \
    gazebo-msgs \
    geometry-msgs \
    joint-state-controller \
    joint-trajectory-controller \
    position-controllers \
    roscpp \
    sensor-msgs \
    std-msgs \
    velocity-controllers \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    effort-controllers \
    gazebo-msgs \
    geometry-msgs \
    joint-state-controller \
    joint-trajectory-controller \
    position-controllers \
    roscpp \
    sensor-msgs \
    std-msgs \
    velocity-controllers \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    effort-controllers \
    gazebo-msgs \
    geometry-msgs \
    joint-state-controller \
    joint-trajectory-controller \
    position-controllers \
    roscpp \
    sensor-msgs \
    std-msgs \
    velocity-controllers \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ERC-BPGC/omnibase-release/archive/release/melodic/omnibase_gazebo/1.0.1-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/omnibase_gazebo"
SRC_URI = "git://github.com/ERC-BPGC/omnibase-release;${ROS_BRANCH};protocol=https"
SRCREV = "eb4dee6ad2d4bf410073bf11977fc040f620e875"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

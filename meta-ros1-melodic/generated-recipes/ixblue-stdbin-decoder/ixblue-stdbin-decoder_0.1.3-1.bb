# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "iXblue parsing library for protocol iXblue stdbin"
AUTHOR = "Romain Reignier <romain.reignier@ixblue.com>"
ROS_AUTHOR = "Adrien BARRAL <adrien.barral@ixblue.com>"
HOMEPAGE = "http://wiki.ros.org/ixblue_stdbin_decoder"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "ixblue_stdbin_decoder"
ROS_BPN = "ixblue_stdbin_decoder"

ROS_BUILD_DEPENDS = " \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libboost-dev} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libboost-system-dev} \
"

ROS_BUILDTOOL_DEPENDS = " \
    cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libboost-dev} \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libboost-system-dev} \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libboost-system-dev} \
    catkin \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    git \
    gtest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ixblue/ixblue_stdbin_decoder-release/archive/release/melodic/ixblue_stdbin_decoder/0.1.3-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/ixblue_stdbin_decoder"
SRC_URI = "git://github.com/ixblue/ixblue_stdbin_decoder-release;${ROS_BRANCH};protocol=https"
SRCREV = "c3711cb5ba1aae23857d752c9520e00808b7939f"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "Metapackage allowing easy installation of Robosense simulation components."
AUTHOR = "Thomas SIMON <thomas.simon@ensta-paris.fr>"
ROS_AUTHOR = "Thomas SIMON"
HOMEPAGE = "http://wiki.ros.org/robosense_simulator"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "robosense_simulator"
ROS_BPN = "robosense_simulator"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    robosense-description \
    robosense-gazebo-plugins \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/tomlogan501/robosense_simulator_release/archive/release/melodic/robosense_simulator/1.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/robosense_simulator"
SRC_URI = "git://github.com/tomlogan501/robosense_simulator_release;${ROS_BRANCH};protocol=https"
SRCREV = "a87490cf75a6704313e12464d8273a6d416d50bc"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

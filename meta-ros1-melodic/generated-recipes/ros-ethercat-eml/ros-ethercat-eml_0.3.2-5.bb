# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "This is an implementation of the EtherCAT master protocol for use wiht ros_ethercar package       based on the work done at Flanders' Mechatronics Technology Centre and Willow Garage."
AUTHOR = "Shadow Robot's software team <software@shadowrobot.com>"
ROS_AUTHOR = "Tom Panis"
HOMEPAGE = "http://ros.org/wiki/ros_ethercat_eml"
SECTION = "devel"
LICENSE = "GPL"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=162b49cfbae9eadf37c9b89b2d2ac6be"

ROS_CN = "ros_ethercat_eml"
ROS_BPN = "ros_ethercat_eml"

ROS_BUILD_DEPENDS = " \
    roscpp \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    roscpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    roscpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/shadow-robot/ros_ethercat_eml-release/archive/release/melodic/ros_ethercat_eml/0.3.2-5.tar.gz
ROS_BRANCH ?= "branch=release/melodic/ros_ethercat_eml"
SRC_URI = "git://github.com/shadow-robot/ros_ethercat_eml-release;${ROS_BRANCH};protocol=https"
SRCREV = "2a7c783516f5fe1f40918bf04c0ef4a6dee5b581"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

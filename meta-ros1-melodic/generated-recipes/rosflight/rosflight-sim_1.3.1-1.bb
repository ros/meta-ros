# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "Software-in-the-loop (SIL) simulator for the ROSflight firmware"
AUTHOR = "James Jackson <superjax08@gmail.com>"
ROS_AUTHOR = "James Jackson"
HOMEPAGE = "http://rosflight.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "rosflight"
ROS_BPN = "rosflight_sim"

ROS_BUILD_DEPENDS = " \
    ${ROS_UNRESOLVED_PLATFORM_PKG_gazebo} \
    gazebo-plugins \
    gazebo-ros \
    geometry-msgs \
    libeigen \
    roscpp \
    rosflight-firmware \
    rosflight-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    ${ROS_UNRESOLVED_PLATFORM_PKG_gazebo} \
    gazebo-plugins \
    gazebo-ros \
    geometry-msgs \
    libeigen \
    roscpp \
    rosflight-firmware \
    rosflight-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ${ROS_UNRESOLVED_PLATFORM_PKG_gazebo} \
    gazebo-plugins \
    gazebo-ros \
    geometry-msgs \
    libeigen \
    roscpp \
    rosflight-firmware \
    rosflight-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/rosflight/rosflight-release/archive/release/melodic/rosflight_sim/1.3.1-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/rosflight_sim"
SRC_URI = "git://github.com/rosflight/rosflight-release;${ROS_BRANCH};protocol=https"
SRCREV = "053ec5800befecf2adc2baee5a8d4e1b73ac9ede"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "Wrapper around qpOASES to make it available to the ROS ecosystem."
AUTHOR = "Geoffrey Biggs <geoff.biggs@tier4.jp>"
HOMEPAGE = "https://projects.coin-or.org/qpOASES"
SECTION = "devel"
LICENSE = "Apache-2.0 & LGPL-2"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d160c31cc0b7b3533fd6cf648b07acc7"

ROS_CN = "qpoases_vendor"
ROS_BPN = "qpoases_vendor"

ROS_BUILD_DEPENDS = " \
    subversion \
"

ROS_BUILDTOOL_DEPENDS = " \
    catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    subversion \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    subversion \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/autoware-ai/qpoases_vendor-release/archive/release/melodic/qpoases_vendor/3.2.1-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/qpoases_vendor"
SRC_URI = "git://github.com/autoware-ai/qpoases_vendor-release;${ROS_BRANCH};protocol=https"
SRCREV = "db5d6e3d29b20d8b3e601a23938e0cc4d89dcff2"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}

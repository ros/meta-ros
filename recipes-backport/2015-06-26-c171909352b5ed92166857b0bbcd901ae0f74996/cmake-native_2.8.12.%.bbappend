cmake_2.8.12.%.bbappend
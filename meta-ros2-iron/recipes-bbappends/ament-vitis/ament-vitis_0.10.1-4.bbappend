# Copyright (c) 2022 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += " \
  ament-cmake-libraries \
"
ROS_BUILDTOOL_DEPENDS += " \
  ament-cmake-gmock-native \
  ament-cmake-gtest-native \
  ament-cmake-native \
  ament-cmake-pytest-native \
  ament-cmake-test-native \
"

# Copyright (c) 2022 Wind River Systems, Inc.

FILES:${PN} += "${libdir}/python3/dist-packages"

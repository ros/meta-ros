# Copyright (c) 2022 Wind River Systems, Inc.

LICENSE = "Apache-2.0"
FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://0001-Add-map-to-udppacketmerger.patch"

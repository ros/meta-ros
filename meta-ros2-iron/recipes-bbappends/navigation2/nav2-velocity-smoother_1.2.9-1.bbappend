# Copyright (c) 2023 Wind River Systems, Inc.

# nav2-velocity-smoother/1.2.5-2-r0/recipe-sysroot/usr/include/class_loader/class_loader/meta_object.hpp:57:27: error: 'class class_loader::impl::AbstractMetaObjectBase' has virtual functions and accessible non-virtual destructor [-Werror=non-virtual-dtor]
CXXFLAGS += "-Wno-error=non-virtual-dtor"

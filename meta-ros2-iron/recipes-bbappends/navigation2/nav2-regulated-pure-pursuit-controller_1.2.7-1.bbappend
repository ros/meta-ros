# Copyright (c) 2024 Wind River Systems, Inc.

CXXFLAGS += "-Wno-error=deprecated-declarations"

CXXFLAGS += "-Wno-error=shadow"

CXXFLAGS += "-Wno-error=non-virtual-dtor"

# Copyright (c) 2024 Wind River Systems, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    rosidl-default-generators-native \
"

ROS_BUILD_DEPENDS += " \
    service-msgs \
"

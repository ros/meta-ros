# Copyright (c) 2022 Víctor Mayoral-Vilches

BBCLASSEXTEND =+ "native"

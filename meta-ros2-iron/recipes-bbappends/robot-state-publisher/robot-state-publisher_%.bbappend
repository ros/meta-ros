# Copyright (c) 2022 Acceleration Robotics S.L. <contact@accelerationrobotics.com>

LICENSE = "BSD-3-Clause"

ROS_BUILDTOOL_DEPENDS += " \
    python3-numpy-native \
"

# Copyright (c) 2021 LG Electronics, Inc.

# nlohmann-json PN is empty don't add runtime dependency on it
ROS_EXEC_DEPENDS:remove = "nlohmann-json"
# websocketpp PN is empty don't add runtime dependency on it
ROS_EXEC_DEPENDS:remove = "websocketpp"

# Copyright (c) 2021 LG Electronics, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    python3-numpy-native \
    rosidl-adapter \
"

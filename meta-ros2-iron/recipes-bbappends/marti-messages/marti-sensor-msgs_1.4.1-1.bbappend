# Copyright (c) 2024 Wind River Systems, Inc.

ROS_EXEC_DEPENDS += " \
    service-msgs \
"

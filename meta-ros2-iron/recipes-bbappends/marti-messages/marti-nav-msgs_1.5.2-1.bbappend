# Copyright (c) 2023 Wind River Systems, Inc.

ROS_EXEC_DEPENDS += " \
    service-msgs \
"

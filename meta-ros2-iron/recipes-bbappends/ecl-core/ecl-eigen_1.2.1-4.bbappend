# Copyright (c) 2020 LG Electronics, Inc.

FILES:${PN}-doc:prepend = "${datadir}/licenses "

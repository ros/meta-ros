# Copyright (c) 2024 Botronics

ROS_BUILDTOOL_DEPENDS += " \
    rosidl-adapter-native \
    generate-parameter-library-py-native \
"

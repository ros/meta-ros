# Copyright (c) 2022 Acceleration Robotics S.L. <contact@accelerationrobotics.com>

inherit setuptools3-base

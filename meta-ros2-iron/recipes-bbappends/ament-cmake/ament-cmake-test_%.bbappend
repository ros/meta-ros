# Copyright (c) 2022 Acceleration Robotics S.L. <contact@accelerationrobotics.com>

inherit distutils3-base

# Copyright (c) 2019 LG Electronics, Inc.
# Copyright (c) 2022 Acceleration Robotics, S.L.

inherit ros_insane_dev_so
BBCLASSEXTEND =+ "native"

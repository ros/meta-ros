# Copyright (c) 2019 LG Electronics, Inc.
# Copyright (c) 2022 Acceleration Robotics S.L. <contact@accelerationrobotics.com>

ROS_BUILD_DEPENDS += " \
    rosidl-cmake \
    rosidl-default-runtime \
    rosidl-generator-cpp \
    rosidl-adapter \
    python3-numpy-native \
"

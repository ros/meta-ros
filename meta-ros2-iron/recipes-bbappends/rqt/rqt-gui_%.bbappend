LICENSE = "BSD-3-Clause"

FILES:${PN} += "${datadir}/lib"

# Copyright (c) 2022-2023 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += " \
    grid-map-cmake-helpers \
"

ROS_BUILDTOOL_DEPENDS += " \
    rosidl-default-generators-native \
"

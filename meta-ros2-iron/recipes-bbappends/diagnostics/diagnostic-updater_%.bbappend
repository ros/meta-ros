ROS_BUILD_DEPENDS += " \
    python3-numpy-native \
"

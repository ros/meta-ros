# Every ROS recipe, generated or not, must contain "inherit ros_distro_${ROS_DISTRO}".
#
# Copyright (c) 2023 Mission Robotics, <dominik@missionrobotics.us>

ROS_DISTRO = "iron"

inherit ${ROS_DISTRO_TYPE}_distro

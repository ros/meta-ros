# Generated by superflore -- DO NOT EDIT
#
# Copyright 2025 Open Source Robotics Foundation

inherit ros_distro_${ROS_DISTRO}
inherit ros_superflore_generated

DESCRIPTION = "Low-level build system macros and infrastructure for ROS."
AUTHOR = "Michael Carroll <michael@openrobotics.org>"
ROS_AUTHOR = "Troy Straszheim"
HOMEPAGE = "http://wiki.ros.org/catkin"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "catkin"
ROS_BPN = "catkin"

ROS_BUILD_DEPENDS = " \
    python3-catkin-pkg \
    python3-empy \
"

ROS_BUILDTOOL_DEPENDS = " \
    cmake-native \
    python3-setuptools-native \
"

ROS_EXPORT_DEPENDS = " \
    gtest \
    python3-catkin-pkg \
    python3-empy \
    python3-nose \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = " \
    cmake-native \
    python3-setuptools-native \
"

ROS_EXEC_DEPENDS = " \
    python3-catkin-pkg \
    python3-empy \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    python3-mock \
    python3-nose \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

SRC_URI = "https://github.com/ros-gbp/catkin-release/archive/release/noetic/catkin/0.8.10-1.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "ef72b9e95f0ef88bb03c911f1cee5fab"
SRC_URI[sha256sum] = "08401b37f85d0a6b153e00408b6e51fdf7b0fd0d485da6ccb808aba401a5518f"
S = "${WORKDIR}/catkin-release-release-noetic-catkin-0.8.10-1"

ROS_COMPONENT_TYPE = "${@ros_distro__get_component_type('catkin', d)}"
ROS_BUILD_TYPE = "catkin"

# Allow the above settings to be overridden.
ROS_INCLUDES_TREE := "${@ros_superflore_generated__get_includes_tree('catkin', d)}"
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/catkin/catkin_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/catkin/catkin-${PV}_common.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/catkin/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_INCLUDES_TREE}/catkin/${BPN}-${PV}.inc

inherit ${ROS_COMPONENT_TYPE}_component
inherit ros_${ROS_BUILD_TYPE}

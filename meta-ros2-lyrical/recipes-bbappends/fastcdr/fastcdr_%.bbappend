# Copyright (c) 2019 LG Electronics, Inc.

inherit ros_insane_dev_so

# Copyright (c) 2026 Wind River Systems, Inc.

LICENSE = "BSD-3-Clause"

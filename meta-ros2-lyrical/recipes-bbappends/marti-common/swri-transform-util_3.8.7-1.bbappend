# Copyright (c) 2024 Wind River Systems, Inc..

FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://boost_replace_deprecated_features.patch"

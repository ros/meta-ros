# Copyright (c) 2026 Wind River Systems, Inc.

LICENSE = "BSD-2-Clause"

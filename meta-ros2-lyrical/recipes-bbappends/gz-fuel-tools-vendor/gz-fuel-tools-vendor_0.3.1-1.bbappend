# Copyright (c) 2024 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += "gz-fuel-tools10"

inherit ros_insane_dev_so

BBCLASSEXTEND = "native nativesdk"

# Copyright (c) 2025 Wind River Systems, Inc.

LICENSE = "GPL-3.0-or-later"

# Copyright (c) 2026 Wind River Systems, Inc.

inherit pkgconfig

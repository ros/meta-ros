# Copyright (c) 2025 Wind River Systems, Inc.

ROS_BUILDTOOL_DEPENDS:append = " \
    ament-cmake-native \
    "

BBCLASSEXTEND = "native nativesdk"

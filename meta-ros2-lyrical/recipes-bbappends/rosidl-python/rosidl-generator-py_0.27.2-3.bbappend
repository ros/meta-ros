# Copyright (c) 2020-2021 LG Electronics, Inc.

inherit python3targetconfig

ROS_EXPORT_DEPENDS += "\
    rosidl-generator-c \
    rosidl-typesupport-c \
    python3-numpy \
"

# Copyright (c) 2021 LG Electronics, Inc.

# ERROR: moveit-ros-benchmarks-2.1.0-1-r0 do_package_qa: QA Issue:
# non -dev/-dbg/nativesdk- package contains symlink .so: moveit-ros-benchmarks path '/work/raspberrypi4-webos-linux-gnueabi/moveit-ros-benchmarks/2.1.0-1-r0/packages-split/moveit-ros-benchmarks/usr/lib/libmoveit_ros_benchmarks.so' [dev-so]
inherit ros_insane_dev_so

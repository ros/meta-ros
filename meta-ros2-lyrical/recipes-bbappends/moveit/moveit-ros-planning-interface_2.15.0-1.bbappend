# Copyright (c) 2021 LG Electronics, Inc.

# ERROR: moveit-ros-planning-interface-2.1.0-1-r0 do_package_qa: QA Issue:
# non -dev/-dbg/nativesdk- package contains symlink .so: moveit-ros-planning-interface path '/work/raspberrypi4-webos-linux-gnueabi/moveit-ros-planning-interface/2.1.0-1-r0/packages-split/moveit-ros-planning-interface/usr/lib/libmoveit_cpp.so'
# non -dev/-dbg/nativesdk- package contains symlink .so: moveit-ros-planning-interface path '/work/raspberrypi4-webos-linux-gnueabi/moveit-ros-planning-interface/2.1.0-1-r0/packages-split/moveit-ros-planning-interface/usr/lib/libmoveit_planning_scene_interface.so'
# non -dev/-dbg/nativesdk- package contains symlink .so: moveit-ros-planning-interface path '/work/raspberrypi4-webos-linux-gnueabi/moveit-ros-planning-interface/2.1.0-1-r0/packages-split/moveit-ros-planning-interface/usr/lib/libmoveit_move_group_interface.so'
# non -dev/-dbg/nativesdk- package contains symlink .so: moveit-ros-planning-interface path '/work/raspberrypi4-webos-linux-gnueabi/moveit-ros-planning-interface/2.1.0-1-r0/packages-split/moveit-ros-planning-interface/usr/lib/libmoveit_common_planning_interface_objects.so'
# [dev-so]
inherit ros_insane_dev_so

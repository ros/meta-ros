# Copyright (c) 2021 LG Electronics, Inc.

# ERROR: moveit-ros-occupancy-map-monitor-2.1.0-1-r0 do_package_qa: QA Issue:
# non -dev/-dbg/nativesdk- package contains symlink .so: moveit-ros-occupancy-map-monitor path '/work/raspberrypi4-webos-linux-gnueabi/moveit-ros-occupancy-map-monitor/2.1.0-1-r0/packages-split/moveit-ros-occupancy-map-monitor/usr/lib/libmoveit_ros_occupancy_map_monitor.so' [dev-so]
inherit ros_insane_dev_so

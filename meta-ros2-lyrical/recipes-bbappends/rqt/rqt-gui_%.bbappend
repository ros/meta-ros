LICENSE = "BSD-3-Clause"

FILES:${PN} += "${datadir}/lib/rqt_gui/rqt_gui"

# Copyright (c) 2023 Wind River Systems, Inc.

inherit pkgconfig

LICENSE = "BSD-3-Clause"

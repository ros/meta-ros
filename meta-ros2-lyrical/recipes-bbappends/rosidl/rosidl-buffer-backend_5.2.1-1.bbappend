ROS_BUILD_DEPENDS += "ament-cmake-ros-core"

BBCLASSEXTEND = "native nativesdk"

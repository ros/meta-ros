# Copyright (c) 2026 Wind River Systems, Inc.

LICENSE = "LGPL-2.1-only & LGPL-3.0-or-later"

# Copyright (c) 2024 Wind River Systems, Inc.

inherit pkgconfig

FILES:${PN}-dev = "${ros_libdir}/libcaer.so"

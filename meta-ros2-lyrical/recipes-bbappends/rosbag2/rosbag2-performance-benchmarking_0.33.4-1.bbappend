# Copyright (c) 2023 Wind River Systems, Inc.

EXTRA_OECMAKE += "-DBUILD_ROSBAG2_BENCHMARKS=ON"

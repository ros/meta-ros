# Copyright (c) 2021 LG Electronics, Inc.

LICENSE = "BSD-3-Clause"

ROS_BUILDTOOL_DEPENDS += "\
    rosidl-adapter-native \
    rosidl-typesupport-fastrtps-cpp-native \
    rosidl-typesupport-fastrtps-c-native \
"

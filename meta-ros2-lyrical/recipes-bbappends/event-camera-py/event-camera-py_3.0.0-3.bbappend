# Copyright (c) 2024 Wind River Systems, Inc.

inherit python3targetconfig

ROS_BUILDTOOL_DEPENDS += "\
    rosidl-default-runtime-native \
"

# Copyright (c) 2026 Wind River Systems, Inc.

LICENSE = "GPL-3.0-only AND LGPL-3.0-only AND BSD-3-Clause"

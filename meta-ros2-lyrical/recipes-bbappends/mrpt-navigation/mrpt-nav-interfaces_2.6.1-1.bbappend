# Copyright (c) 2024 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += "\
    action-msgs \
"

LICENSE = "BSD-3-Clause"

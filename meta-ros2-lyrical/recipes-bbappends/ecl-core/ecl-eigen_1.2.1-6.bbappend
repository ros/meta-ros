# Copyright (c) 2020 LG Electronics, Inc.

FILES:${PN}-doc:prepend = "${datadir}/licenses "

# Setting LICENSE from BSD to BSD-3-Clause to be SPDX compliant
LICENSE = "BSD-3-Clause"

# Copyright (c) 2021 LG Electronics, Inc.

DEPENDS += "eigen3-cmake-module"

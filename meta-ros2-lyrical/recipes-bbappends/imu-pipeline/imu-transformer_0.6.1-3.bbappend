# Copyright (c) 2026 Wind River Systems, Inc.

LICENSE = "GPL-3.0-only"

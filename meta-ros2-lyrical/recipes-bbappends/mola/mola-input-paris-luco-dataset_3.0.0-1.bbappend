# Copyright (c) 2024 Wind River Systems, Inc.

FILES:${PN}-dev =+ "${ros_libdir}/lib*${SOLIBSDEV}"

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "ROS nodes for various robotics sensors via mrpt-hwdrivers. Metapackage for all mrpt_sensor packages."
AUTHOR = "Jose-Luis Blanco-Claraco <jlblanco@ual.es>"
ROS_AUTHOR = "Jose-Luis Blanco-Claraco"
HOMEPAGE = "https://github.com/mrpt-ros-pkg/mrpt_sensors/"
SECTION = "devel"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=4633480cdd27d7906aaf3ef4b72014b2"

ROS_CN = "mrpt_sensors"
ROS_BPN = "mrpt_sensors"

ROS_BUILD_DEPENDS = " \
    mrpt-generic-sensor \
    mrpt-sensor-bumblebee-stereo \
    mrpt-sensor-gnss-nmea \
    mrpt-sensor-gnss-novatel \
    mrpt-sensor-imu-taobotics \
    mrpt-sensorlib \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    mrpt-generic-sensor \
    mrpt-sensor-bumblebee-stereo \
    mrpt-sensor-gnss-nmea \
    mrpt-sensor-gnss-novatel \
    mrpt-sensor-imu-taobotics \
    mrpt-sensorlib \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    mrpt-generic-sensor \
    mrpt-sensor-bumblebee-stereo \
    mrpt-sensor-gnss-nmea \
    mrpt-sensor-gnss-novatel \
    mrpt-sensor-imu-taobotics \
    mrpt-sensorlib \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-xmllint \
    ament-lint-auto \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/mrpt_sensors-release/archive/release/lyrical/mrpt_sensors/0.3.0-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/mrpt_sensors"
SRC_URI = "git://github.com/ros2-gbp/mrpt_sensors-release;${ROS_BRANCH};protocol=https"
SRCREV = "0e130323763df3b2b6a1bafd7ba2dbf81505b667"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

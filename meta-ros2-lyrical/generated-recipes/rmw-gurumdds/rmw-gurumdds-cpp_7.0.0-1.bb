# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "Implement the ROS middleware interface using GurumNetworks GurumDDS static code generation in C++."
AUTHOR = "Donghyeon Lee <donghyeon@gurumdds.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "rmw_gurumdds"
ROS_BPN = "rmw_gurumdds_cpp"

ROS_BUILD_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-gurumdds-3.2} \
    fastcdr \
    gurumdds-cmake-module \
    rcutils \
    rmw \
    rmw-dds-common \
    rosidl-buffer-backend-registry \
    rosidl-dynamic-typesupport \
    rosidl-generator-dds-idl \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    tracetools \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    ament-cmake-ros-core-native \
    rosidl-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-gurumdds-3.2} \
    fastcdr \
    gurumdds-cmake-module \
    rmw-dds-common \
    rosidl-dynamic-typesupport \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    tracetools \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    rcpputils \
    rcutils \
    rmw \
    rosidl-buffer-backend-registry \
    rosidl-dynamic-typesupport \
    tracetools \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/rmw_gurumdds-release/archive/release/lyrical/rmw_gurumdds_cpp/7.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/rmw_gurumdds_cpp"
SRC_URI = "git://github.com/ros2-gbp/rmw_gurumdds-release;${ROS_BRANCH};protocol=https"
SRCREV = "04f7fc0efdec6f2e280b5052c6f845be7d8d98af"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "Helper functions for displaying and debugging MoveIt data in Rviz via published markers"
AUTHOR = "Dave Coleman <dave@picknik.ai>"
ROS_AUTHOR = "Dave Coleman <dave@picknik.ai>"
HOMEPAGE = "https://github.com/ros-planning/moveit_visual_tools"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "moveit_visual_tools"
ROS_BPN = "moveit_visual_tools"

ROS_BUILD_DEPENDS = "\
    ament-index-cpp \
    geometric-shapes \
    geometry-msgs \
    graph-msgs \
    interactive-markers \
    moveit-common \
    moveit-core \
    moveit-msgs \
    moveit-ros-planning \
    rclcpp \
    rviz-visual-tools \
    std-msgs \
    tf2-eigen \
    tf2-ros \
    trajectory-msgs \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    ament-index-cpp \
    geometric-shapes \
    geometry-msgs \
    graph-msgs \
    interactive-markers \
    moveit-common \
    moveit-core \
    moveit-msgs \
    moveit-ros-planning \
    rclcpp \
    rviz-visual-tools \
    std-msgs \
    tf2-eigen \
    tf2-ros \
    trajectory-msgs \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-index-cpp \
    geometric-shapes \
    geometry-msgs \
    graph-msgs \
    interactive-markers \
    moveit-common \
    moveit-core \
    moveit-msgs \
    moveit-ros-planning \
    rclcpp \
    rviz-visual-tools \
    std-msgs \
    tf2-eigen \
    tf2-ros \
    trajectory-msgs \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/moveit_visual_tools-release/archive/release/lyrical/moveit_visual_tools/4.2.0-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/moveit_visual_tools"
SRC_URI = "git://github.com/ros2-gbp/moveit_visual_tools-release;${ROS_BRANCH};protocol=https"
SRCREV = "5a0e0925874d8137054c0ee838f7532ef1c0f96c"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

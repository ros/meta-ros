# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "Robot model description package for Wuji Hand 2 (Beta 1) with URDF, MJCF, and USD assets for simulation and ROS2 visualization."
AUTHOR = "Wuji Technology <support@wuji.tech>"
HOMEPAGE = "https://wuji.tech"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "wuji_description"
ROS_BPN = "wuji_hand2_beta1_description"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = ""

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/wuji-technology/wuji-description-release/archive/release/lyrical/wuji_hand2_beta1_description/2026.8.19-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/wuji_hand2_beta1_description"
SRC_URI = "git://github.com/wuji-technology/wuji-description-release;${ROS_BRANCH};protocol=https"
SRCREV = "657e150bceba0f3966785902861d6f6edad1fb49"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

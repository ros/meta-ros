# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "Franka arm ROS example for RoboPlan."
AUTHOR = "Sebastian Castro <sebas.a.castro@gmail.com>"
HOMEPAGE = "https://roboplan-ros.readthedocs.io"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "roboplan_ros"
ROS_BPN = "roboplan_ros_franka"

ROS_BUILD_DEPENDS = "\
    roboplan \
    roboplan-example-models \
    roboplan-ros-examples \
    xacro \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    roboplan \
    roboplan-example-models \
    roboplan-ros-examples \
    xacro \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    controller-manager \
    joint-state-broadcaster \
    joint-trajectory-controller \
    parallel-gripper-controller \
    roboplan \
    roboplan-example-models \
    roboplan-ros-examples \
    robot-state-publisher \
    topic-tools \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/roboplan_ros-release/archive/release/lyrical/roboplan_ros_franka/0.6.0-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/roboplan_ros_franka"
SRC_URI = "git://github.com/ros2-gbp/roboplan_ros-release;${ROS_BRANCH};protocol=https"
SRCREV = "ad928b59ac0c666e993c1fee72ef8f49869f5337"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

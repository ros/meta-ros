# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "An open source camera stack and framework for Linux, Android, and ChromeOS"
AUTHOR = "Christian Rauch <Rauch.Christian@gmx.de>"
ROS_AUTHOR = "libcamera project <libcamera-devel@lists.libcamera.org>"
HOMEPAGE = "https://libcamera.org"
SECTION = "devel"
LICENSE = "Apache-2.0 & BSD-2-Clause & BSD-3-Clause & GPL-2.0-or-later & LGPL-2.1-or-later"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "libcamera"
ROS_BPN = "libcamera"

ROS_BUILD_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libyuv-dev} \
    libyaml \
    openssl \
    python3 \
    python3-jinja2 \
    python3-ply \
    python3-pybind11 \
    python3-pyyaml \
    udev \
"

ROS_BUILDTOOL_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-meson-native} \
    git-native \
    pkgconfig-native \
"

ROS_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libyuv-dev} \
    libyaml \
    openssl \
    python3 \
    udev \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = ""

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libyuv-dev} \
    libyaml \
    openssl \
    python3 \
    udev \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/libcamera-release/archive/release/lyrical/libcamera/0.7.2-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/libcamera"
SRC_URI = "git://github.com/ros2-gbp/libcamera-release;${ROS_BRANCH};protocol=https"
SRCREV = "3c9116190807e2a253932e140c17d14ecf3ef266"

ROS_BUILD_TYPE = "meson"

inherit ros_${ROS_BUILD_TYPE}

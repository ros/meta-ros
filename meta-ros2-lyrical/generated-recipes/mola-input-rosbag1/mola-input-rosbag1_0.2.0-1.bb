# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "MOLA DataSource from ROS1 bag files that does not need a ROS1 installation"
AUTHOR = "Jose-Luis Blanco-Claraco <joseluisblancoc@gmail.com>"
HOMEPAGE = "https://github.com/MOLAorg/mola_input_ros1bag"
SECTION = "devel"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d0998f4eabe3d0099aca1e1f57f44fe6"

ROS_CN = "mola_input_rosbag1"
ROS_BPN = "mola_input_rosbag1"

ROS_BUILD_DEPENDS = " \
    boost \
    bzip2 \
    geometry-msgs \
    lz4 \
    mola-common \
    mola-kernel \
    mrpt-libmaps \
    mrpt-libobs \
    opencv \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = " \
    cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    boost \
    bzip2 \
    geometry-msgs \
    lz4 \
    mola-common \
    mola-kernel \
    mrpt-libmaps \
    mrpt-libobs \
    opencv \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    boost \
    bzip2 \
    geometry-msgs \
    lz4 \
    mola-common \
    mola-kernel \
    mrpt-libmaps \
    mrpt-libobs \
    opencv \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/mola_input_rosbag1-release/archive/release/lyrical/mola_input_rosbag1/0.2.0-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/mola_input_rosbag1"
SRC_URI = "git://github.com/ros2-gbp/mola_input_rosbag1-release;${ROS_BRANCH};protocol=https"
SRCREV = "14dc6dc724abbb04bd05b33991fdce0fa23f52cc"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

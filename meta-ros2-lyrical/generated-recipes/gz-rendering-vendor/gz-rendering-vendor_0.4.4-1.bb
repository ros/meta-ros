# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "Vendor package for: gz-rendering 10.0.2      Gazebo Rendering: Rendering library for robot applications"
AUTHOR = "Addisu Z. Taddese <addisuzt@intrinsic.ai>"
HOMEPAGE = "https://github.com/gazebosim/gz-rendering"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=20;endline=20;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "gz_rendering_vendor"
ROS_BPN = "gz_rendering_vendor"

ROS_BUILD_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libfreeimage-dev} \
    freeglut \
    glew \
    gz-cmake-vendor \
    gz-common-vendor \
    gz-math-vendor \
    gz-ogre-next-vendor \
    gz-plugin-vendor \
    gz-utils-vendor \
    libxi \
    libxmu \
    mesa \
    ogre \
    util-linux \
    vulkan-headers \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-test-native \
    ament-cmake-vendor-package-native \
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    gz-cmake-vendor \
    gz-common-vendor \
    gz-math-vendor \
    gz-ogre-next-vendor \
    gz-plugin-vendor \
    gz-utils-vendor \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-glslang-dev} \
    ${ROS_UNRESOLVED_DEP-glslc} \
    ${ROS_UNRESOLVED_DEP-libx11-xcb-dev} \
    ${ROS_UNRESOLVED_DEP-libxcb-randr0-dev} \
    boost \
    freetype \
    gz-tools-vendor \
    libsdl2 \
    libtinyxml2 \
    libx11 \
    libxaw \
    libxrandr \
    poco \
    rapidjson \
    shaderc \
    spdlog \
    spdlog-vendor \
    tbb \
    zziplib \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-export-dependencies-native \
    ament-cmake-libraries-native \
    ament-package-native \
    git-native \
    python3-catkin-pkg-native \
    python3-setuptools-native \
    python3-vcstool-native \
"

ROS_EXEC_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libfreeimage-dev} \
    freeglut \
    glew \
    gz-cmake-vendor \
    gz-common-vendor \
    gz-math-vendor \
    gz-ogre-next-vendor \
    gz-plugin-vendor \
    gz-utils-vendor \
    libxi \
    libxmu \
    mesa \
    ogre \
    util-linux \
    vulkan-headers \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-xvfb} \
    ament-cmake-copyright \
    ament-cmake-lint-cmake \
    ament-cmake-xmllint \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/gz_rendering_vendor-release/archive/release/lyrical/gz_rendering_vendor/0.4.4-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/gz_rendering_vendor"
SRC_URI = "git://github.com/ros2-gbp/gz_rendering_vendor-release;${ROS_BRANCH};protocol=https"
SRCREV = "781d06a540792b22af4485518e5829d46b98472b"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

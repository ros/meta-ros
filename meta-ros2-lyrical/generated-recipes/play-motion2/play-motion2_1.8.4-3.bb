# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "Play a pre-recorded motion on a robot"
AUTHOR = "Noel Jimenez <noel.jimenez@pal-robotics.com>"
ROS_AUTHOR = "Noel Jimenez <noel.jimenez@pal-robotics.com>"
HOMEPAGE = "https://github.com/pal-robotics/play_motion2"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "play_motion2"
ROS_BPN = "play_motion2"

ROS_BUILD_DEPENDS = "\
    backward-ros \
    control-msgs \
    controller-manager-msgs \
    lifecycle-msgs \
    moveit-ros-planning-interface \
    play-motion2-msgs \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rclcpp-lifecycle \
    sensor-msgs \
    std-msgs \
    trajectory-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native \
    ament-cmake-python-native \
"

ROS_EXPORT_DEPENDS = "\
    backward-ros \
    control-msgs \
    controller-manager-msgs \
    moveit-ros-planning-interface \
    play-motion2-msgs \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rclcpp-lifecycle \
    sensor-msgs \
    trajectory-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libcurl-dev} \
    ${ROS_UNRESOLVED_DEP-libexpected-dev} \
    ${ROS_UNRESOLVED_DEP-liboctomap-dev} \
    action-msgs \
    ament-index-cpp \
    ament-index-python \
    angles \
    assimp \
    boost \
    builtin-interfaces \
    bullet \
    class-loader \
    common-interfaces \
    composition-interfaces \
    console-bridge \
    console-bridge-vendor \
    diagnostic-msgs \
    eigen-stl-containers \
    elfutils \
    fastcdr \
    fcl \
    fmt \
    generate-parameter-library \
    geometric-shapes \
    geometry-msgs \
    google-benchmark \
    google-benchmark-vendor \
    kdl-parser \
    libeigen \
    libstatistics-collector \
    libtinyxml2 \
    libyaml \
    libyaml-vendor \
    lttng-ust \
    message-filters \
    moveit-common \
    moveit-core \
    moveit-msgs \
    moveit-ros-move-group \
    moveit-ros-occupancy-map-monitor \
    moveit-ros-planning \
    moveit-ros-warehouse \
    object-recognition-msgs \
    octomap-msgs \
    openssl \
    orocos-kdl \
    osqp-vendor \
    pluginlib \
    python3 \
    random-numbers \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-logging-implementation \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclpy \
    rcpputils \
    rcutils \
    resource-retriever \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-buffer \
    rosidl-buffer-backend \
    rosidl-buffer-py \
    rosidl-cmake \
    rosidl-core-runtime \
    rosidl-dynamic-typesupport \
    rosidl-generator-py \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    rsl \
    ruckig \
    service-msgs \
    shape-msgs \
    srdfdom \
    statistics-msgs \
    std-srvs \
    tcb-span \
    tf2 \
    tf2-eigen \
    tf2-geometry-msgs \
    tf2-kdl \
    tf2-msgs \
    tf2-ros \
    tracetools \
    type-description-interfaces \
    unique-identifier-msgs \
    urdf \
    urdf-parser-plugin \
    urdfdom \
    urdfdom-headers \
    visualization-msgs \
    warehouse-ros \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libgtest-dev-native} \
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-gmock-native \
    ament-cmake-gtest-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-native \
    ament-cmake-ros-core-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-package-native \
    cmake-native \
    eigen3-cmake-module-native \
    generate-parameter-library-py-native \
    gtest-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-jinja2-native \
    python3-native \
    python3-pyyaml-native \
    python3-setuptools-native \
    python3-typeguard-native \
    rcpputils-native \
    rcutils-native \
    rosidl-buffer-native \
    rosidl-cmake-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-type-description-native \
    rosidl-pycommon-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-interface-native \
"

ROS_EXEC_DEPENDS = "\
    backward-ros \
    control-msgs \
    controller-manager-msgs \
    launch \
    launch-ros \
    lifecycle-msgs \
    moveit-ros-planning-interface \
    play-motion2-msgs \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rclcpp-lifecycle \
    sensor-msgs \
    std-msgs \
    trajectory-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-cmake-pytest \
    ament-index-cpp \
    ament-lint-auto \
    ament-lint-common \
    controller-interface \
    controller-manager \
    hardware-interface \
    joint-state-broadcaster \
    joint-trajectory-controller \
    launch-testing-ament-cmake \
    pluginlib \
    realtime-tools \
    robot-state-publisher \
    sensor-msgs \
    xacro \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/play_motion2-release/archive/release/lyrical/play_motion2/1.8.4-3.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/play_motion2"
SRC_URI = "git://github.com/ros2-gbp/play_motion2-release;${ROS_BRANCH};protocol=https"
SRCREV = "c4030e3315b1132fb58a7648f3bb7f28f926878f"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "Headless spectral ocean-wave synthesis library: TMA/JONSWAP/Pierson-Moskowitz     spectra with directional spreading and dispersion, after Horvath (2015).     Exports the ehukai::ehukai CMake target.      This manifest exists so the library can be developed as a peer of its     consumers in a colcon workspace. It is a plain CMake package — colcon does     not change how it is configured, built or installed, and it is not a ROS     package in any other sense. The Debian packaging (cmake/Packaging.cmake) and     a standalone cmake build are unaffected."
AUTHOR = "Honu Robotics <info@honurobotics.com>"
ROS_AUTHOR = "Christopher Jon Horvath"
HOMEPAGE = "https://github.com/HonuRobotics/ehukai"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=19;endline=19;md5=a807c33e2269cc13a057985af3c05efe"

ROS_CN = "ehukai"
ROS_BPN = "ehukai"

ROS_BUILD_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libimath-dev} \
    libeigen \
    tbb \
"

ROS_BUILDTOOL_DEPENDS = "\
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libimath-dev} \
    libeigen \
    tbb \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libimath-dev} \
    libeigen \
    tbb \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/ehukai-release/archive/release/lyrical/ehukai/0.0.3-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/ehukai"
SRC_URI = "git://github.com/ros2-gbp/ehukai-release;${ROS_BRANCH};protocol=https"
SRCREV = "0ea1b183bd30acdf4f17925f8d47f561c642f64d"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

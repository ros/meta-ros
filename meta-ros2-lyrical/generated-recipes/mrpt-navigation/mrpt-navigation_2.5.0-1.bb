# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "Tools related to the Mobile Robot Programming Toolkit (MRPT).     Refer to https://wiki.ros.org/mrpt_navigation for further documentation."
AUTHOR = "Jose-Luis Blanco-Claraco <jlblanco@ual.es>"
ROS_AUTHOR = "Jose-Luis Blanco-Claraco"
HOMEPAGE = "https://github.com/mrpt-ros-pkg/mrpt_navigation"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "mrpt_navigation"
ROS_BPN = "mrpt_navigation"

ROS_BUILD_DEPENDS = "\
    ament-cmake-lint-cmake \
    ament-cmake-xmllint \
    ament-lint-auto \
    mrpt-map-server \
    mrpt-msgs-bridge \
    mrpt-nav-interfaces \
    mrpt-pf-localization \
    mrpt-pointcloud-pipeline \
    mrpt-reactivenav2d \
    mrpt-tps-astar-planner \
    mrpt-tutorials \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    ament-cmake-lint-cmake \
    ament-cmake-xmllint \
    ament-lint-auto \
    mrpt-map-server \
    mrpt-msgs-bridge \
    mrpt-nav-interfaces \
    mrpt-pf-localization \
    mrpt-pointcloud-pipeline \
    mrpt-reactivenav2d \
    mrpt-tps-astar-planner \
    mrpt-tutorials \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    action-msgs \
    ament-index-cpp \
    boost \
    builtin-interfaces \
    class-loader \
    cli11 \
    composition-interfaces \
    cv-bridge \
    fastcdr \
    gcc-runtime \
    geometry-msgs \
    glfw \
    gps-msgs \
    libeigen \
    libstatistics-collector \
    libtinyxml2 \
    libyaml \
    libyaml-vendor \
    lttng-ust \
    message-filters \
    mola-common \
    mola-imu-preintegration \
    mola-pose-list \
    mola-relocalization \
    mp2p-icp \
    mp2p-icp-core \
    mp2p-icp-viz \
    mrpt-libbase \
    mrpt-libgui \
    mrpt-libmaps \
    mrpt-libmath \
    mrpt-libnav \
    mrpt-libobs \
    mrpt-libopengl \
    mrpt-libposes \
    mrpt-libros-bridge \
    mrpt-libslam \
    mrpt-libtclap \
    mrpt-msgs \
    mrpt-path-planning \
    mvsim \
    nanoflann-vendor \
    nav-msgs \
    opencv \
    orocos-kdl \
    pluginlib \
    pose-cov-ops \
    protobuf \
    python3 \
    python3-numpy \
    python3-pip \
    python3-protobuf \
    python3-pybind11 \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-logging-implementation \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rcpputils \
    rcutils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosbag2-cpp \
    rosbag2-storage \
    rosgraph-msgs \
    rosidl-buffer \
    rosidl-buffer-backend \
    rosidl-buffer-py \
    rosidl-cmake \
    rosidl-core-runtime \
    rosidl-dynamic-typesupport \
    rosidl-generator-py \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    sensor-msgs \
    service-msgs \
    statistics-msgs \
    std-msgs \
    stereo-msgs \
    suitesparse-cholmod \
    suitesparse-cxsparse \
    tbb \
    tf2 \
    tf2-geometry-msgs \
    tf2-msgs \
    tf2-ros \
    tracetools \
    type-description-interfaces \
    unique-identifier-msgs \
    unzip \
    visualization-msgs \
    wget \
    yaml-cpp \
    yaml-cpp-vendor \
    zeromq \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-ros-core-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-lint-cmake-native \
    ament-package-native \
    ament-xmllint-native \
    cmake-native \
    gcc-runtime-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-native \
    python3-setuptools-native \
    rcpputils-native \
    rcutils-native \
    rosidl-buffer-native \
    rosidl-cmake-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-type-description-native \
    rosidl-pycommon-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-interface-native \
"

ROS_EXEC_DEPENDS = "\
    ament-cmake-lint-cmake \
    ament-cmake-xmllint \
    ament-lint-auto \
    mrpt-map-server \
    mrpt-msgs-bridge \
    mrpt-nav-interfaces \
    mrpt-pf-localization \
    mrpt-pointcloud-pipeline \
    mrpt-reactivenav2d \
    mrpt-tps-astar-planner \
    mrpt-tutorials \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/mrpt_navigation-release/archive/release/lyrical/mrpt_navigation/2.5.0-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/mrpt_navigation"
SRC_URI = "git://github.com/ros2-gbp/mrpt_navigation-release;${ROS_BRANCH};protocol=https"
SRCREV = "79021092dcb09c3d4c10ff1c231c8f1ec3a82660"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

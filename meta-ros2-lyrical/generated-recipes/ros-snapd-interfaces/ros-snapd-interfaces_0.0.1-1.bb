# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "Interface definitions for ros2-snapd."
AUTHOR = "Ubuntu Robotics <ubuntu-robotics@canonical.com>"
ROS_AUTHOR = "Jeremie Deray <jeremie.deray@canonical.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "GPL-3.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=e4c74a520650d71beb18ceaa66a24c70"

ROS_CN = "ros_snapd_interfaces"
ROS_BPN = "ros_snapd_interfaces"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    rosidl-default-generators-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    rosidl-default-runtime \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/ros_snapd_interfaces-release/archive/release/lyrical/ros_snapd_interfaces/0.0.1-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/ros_snapd_interfaces"
SRC_URI = "git://github.com/ros2-gbp/ros_snapd_interfaces-release;${ROS_BRANCH};protocol=https"
SRCREV = "c29bd0272d688d809bdefbba3e20207915ec69fb"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

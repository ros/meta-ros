# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "A C++ library offering a GTSAM ⇆ mrpt-serialization bridge."
AUTHOR = "Jose-Luis Blanco-Claraco <joseluisblancoc@gmail.com>"
HOMEPAGE = "https://github.com/MRPT/gtsam2mrpt_serial"
SECTION = "devel"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=4633480cdd27d7906aaf3ef4b72014b2"

ROS_CN = "gtsam2mrpt_serial"
ROS_BPN = "gtsam2mrpt_serial"

ROS_BUILD_DEPENDS = "\
    gtsam \
    mola-common \
    mrpt-containers \
    mrpt-io \
    mrpt-math \
    mrpt-poses \
    mrpt-random \
    mrpt-rtti \
    mrpt-serialization \
    mrpt-system \
"

ROS_BUILDTOOL_DEPENDS = "\
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    gtsam \
    mola-common \
    mrpt-containers \
    mrpt-io \
    mrpt-math \
    mrpt-poses \
    mrpt-random \
    mrpt-rtti \
    mrpt-serialization \
    mrpt-system \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    gtsam \
    mola-common \
    mrpt-containers \
    mrpt-io \
    mrpt-math \
    mrpt-poses \
    mrpt-random \
    mrpt-rtti \
    mrpt-serialization \
    mrpt-system \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/gtsam2mrpt_serial-release/archive/release/lyrical/gtsam2mrpt_serial/0.4.0-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/gtsam2mrpt_serial"
SRC_URI = "git://github.com/ros2-gbp/gtsam2mrpt_serial-release;${ROS_BRANCH};protocol=https"
SRCREV = "cdca7e3d8cfad394a1db5b64feb5f7ff49b68d07"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

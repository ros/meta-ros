# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "YASMIN (Yet Another State MachINe) for ROS 2"
AUTHOR = "Miguel Ángel González Santamarta <mgons@unileon.es>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "yasmin"
ROS_BPN = "yasmin_ros"

ROS_BUILD_DEPENDS = "\
    example-interfaces \
    geometry-msgs \
    pluginlib \
    rclcpp \
    rclcpp-action \
    rclpy \
    ros-environment \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-msgs \
    tf2-py \
    tf2-ros \
    tf2-ros-py \
    yasmin \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    ament-cmake-python-native \
"

ROS_EXPORT_DEPENDS = "\
    example-interfaces \
    geometry-msgs \
    pluginlib \
    rclcpp \
    rclcpp-action \
    rclpy \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-msgs \
    tf2-py \
    tf2-ros \
    tf2-ros-py \
    yasmin \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    example-interfaces \
    geometry-msgs \
    pluginlib \
    rclcpp \
    rclcpp-action \
    rclpy \
    rosidl-runtime-py \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-msgs \
    tf2-py \
    tf2-ros \
    tf2-ros-py \
    yasmin \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-cmake-pytest \
    example-interfaces \
    python3-pytest \
    python3-pytest-cov \
    std-msgs \
    tf2 \
    tf2-msgs \
    tf2-py \
    tf2-ros \
    tf2-ros-py \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/yasmin-release/archive/release/lyrical/yasmin_ros/6.1.1-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/yasmin_ros"
SRC_URI = "git://github.com/ros2-gbp/yasmin-release;${ROS_BRANCH};protocol=https"
SRCREV = "748b03be89fd3ae508ebc53528c07497f2a8aa04"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

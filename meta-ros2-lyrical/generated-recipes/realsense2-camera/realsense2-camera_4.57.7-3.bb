# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "RealSense camera package allowing access to RealSense D400 3D cameras"
AUTHOR = "LibRealSense Team <rsswsdk@realsensecloud.onmicrosoft.com>"
ROS_AUTHOR = "LibRealSense Team <rsswsdk@realsensecloud.onmicrosoft.com>"
HOMEPAGE = "http://www.ros.org/wiki/RealSense"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "realsense2_camera"
ROS_BPN = "realsense2_camera"

ROS_BUILD_DEPENDS = "\
    builtin-interfaces \
    cv-bridge \
    diagnostic-updater \
    geometry-msgs \
    image-transport \
    libeigen \
    librealsense2 \
    lifecycle-msgs \
    nav-msgs \
    rclcpp \
    rclcpp-components \
    rclcpp-lifecycle \
    realsense2-camera-msgs \
    ros-environment \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    builtin-interfaces \
    cv-bridge \
    diagnostic-updater \
    geometry-msgs \
    image-transport \
    libeigen \
    librealsense2 \
    lifecycle-msgs \
    nav-msgs \
    rclcpp \
    rclcpp-components \
    rclcpp-lifecycle \
    realsense2-camera-msgs \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-ros \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    action-msgs \
    ament-index-cpp \
    class-loader \
    composition-interfaces \
    diagnostic-msgs \
    fastcdr \
    gcc-runtime \
    glfw \
    libstatistics-collector \
    libtinyxml2 \
    libx11 \
    libyaml \
    libyaml-vendor \
    lttng-ust \
    mesa \
    message-filters \
    opencv \
    pluginlib \
    python3-numpy \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-logging-implementation \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp-action \
    rclpy \
    rcpputils \
    rcutils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-buffer \
    rosidl-buffer-backend \
    rosidl-buffer-py \
    rosidl-cmake \
    rosidl-core-runtime \
    rosidl-dynamic-typesupport \
    rosidl-generator-py \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    service-msgs \
    statistics-msgs \
    tf2-msgs \
    tracetools \
    type-description-interfaces \
    unique-identifier-msgs \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-ros-core-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-package-native \
    cmake-native \
    gcc-runtime-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-native \
    python3-setuptools-native \
    rcpputils-native \
    rcutils-native \
    rosidl-buffer-native \
    rosidl-cmake-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-type-description-native \
    rosidl-pycommon-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-interface-native \
"

ROS_EXEC_DEPENDS = "\
    builtin-interfaces \
    cv-bridge \
    diagnostic-updater \
    geometry-msgs \
    image-transport \
    launch-ros \
    libeigen \
    librealsense2 \
    lifecycle-msgs \
    nav-msgs \
    rclcpp \
    rclcpp-components \
    rclcpp-lifecycle \
    realsense2-camera-msgs \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-ros \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-cmake-pytest \
    launch-pytest \
    launch-testing \
    python3-numpy \
    python3-requests \
    python3-tqdm \
    ros2topic \
    sensor-msgs-py \
    tf2-ros-py \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/realsense-ros-release/archive/release/lyrical/realsense2_camera/4.57.7-3.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/realsense2_camera"
SRC_URI = "git://github.com/ros2-gbp/realsense-ros-release;${ROS_BRANCH};protocol=https"
SRCREV = "cbef2b63cdf9f6e3c14db3a52c395e690f99c6ec"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

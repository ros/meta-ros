# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "nav2_mppi_controller"
AUTHOR = "Steve Macenski <stevenmacenski@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "navigation2"
ROS_BPN = "nav2_mppi_controller"

ROS_BUILD_DEPENDS = "\
    angles \
    backward-ros \
    geometry-msgs \
    libeigen \
    nav-msgs \
    nav2-common \
    nav2-core \
    nav2-costmap-2d \
    nav2-msgs \
    nav2-ros-common \
    nav2-util \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    std-msgs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    ament-cmake-ros-native \
"

ROS_EXPORT_DEPENDS = "\
    backward-ros \
    geometry-msgs \
    nav-msgs \
    nav2-core \
    nav2-costmap-2d \
    nav2-msgs \
    nav2-ros-common \
    nav2-util \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    std-msgs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    backward-ros \
    geometry-msgs \
    nav-msgs \
    nav2-core \
    nav2-costmap-2d \
    nav2-msgs \
    nav2-ros-common \
    nav2-util \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    std-msgs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-cmake-ros \
    ament-lint-auto \
    ament-lint-common \
    google-benchmark \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/navigation2-release/archive/release/lyrical/nav2_mppi_controller/1.5.1-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/nav2_mppi_controller"
SRC_URI = "git://github.com/ros2-gbp/navigation2-release;${ROS_BRANCH};protocol=https"
SRCREV = "f36fba5cd856efa489a0cb1988b5e2060b63e5d1"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "Vendor package for: gz-plugin 4.0.0      Gazebo Plugin : Cross-platform C++ library for dynamically loading plugins."
AUTHOR = "Addisu Z. Taddese <addisuzt@intrinsic.ai>"
HOMEPAGE = "https://github.com/gazebosim/gz-plugin"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=20;endline=20;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "gz_plugin_vendor"
ROS_BPN = "gz_plugin_vendor"

ROS_BUILD_DEPENDS = "\
    gz-cmake-vendor \
    gz-tools-vendor \
    gz-utils-vendor \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-test-native \
    ament-cmake-vendor-package-native \
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    gz-cmake-vendor \
    gz-tools-vendor \
    gz-utils-vendor \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    spdlog \
    spdlog-vendor \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-export-dependencies-native \
    ament-cmake-libraries-native \
    ament-package-native \
    git-native \
    python3-catkin-pkg-native \
    python3-setuptools-native \
    python3-vcstool-native \
"

ROS_EXEC_DEPENDS = "\
    gz-cmake-vendor \
    gz-tools-vendor \
    gz-utils-vendor \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-copyright \
    ament-cmake-lint-cmake \
    ament-cmake-xmllint \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/gz_plugin_vendor-release/archive/release/lyrical/gz_plugin_vendor/0.3.1-3.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/gz_plugin_vendor"
SRC_URI = "git://github.com/ros2-gbp/gz_plugin_vendor-release;${ROS_BRANCH};protocol=https"
SRCREV = "8730533cc66fa5e4e4e4d3e3ea28d731ae3c07ed"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

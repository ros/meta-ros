# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "ROS 2 Gazebo plugins for TeleportIngestors and TeleportDispensers"
AUTHOR = "Luca Della Vedova <luca@openrobotics.org>"
ROS_AUTHOR = "Luca Della Vedova"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=3dce4ba60d7e51ec64f3c3dc18672dd3"

ROS_CN = "rmf_simulation"
ROS_BPN = "rmf_robot_sim_gz_plugins"

ROS_BUILD_DEPENDS = "\
    gz-msgs-vendor \
    gz-plugin-vendor \
    gz-rendering-vendor \
    gz-sim-vendor \
    gz-transport-vendor \
    libeigen \
    rclcpp \
    rmf-building-map-msgs \
    rmf-building-sim-gz-plugins \
    rmf-dispenser-msgs \
    rmf-fleet-msgs \
    rmf-ingestor-msgs \
    rmf-robot-sim-common \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    gz-msgs-vendor \
    gz-plugin-vendor \
    gz-rendering-vendor \
    gz-sim-vendor \
    gz-transport-vendor \
    libeigen \
    rclcpp \
    rmf-building-map-msgs \
    rmf-building-sim-gz-plugins \
    rmf-dispenser-msgs \
    rmf-fleet-msgs \
    rmf-ingestor-msgs \
    rmf-robot-sim-common \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-glslang-dev} \
    ${ROS_UNRESOLVED_DEP-glslc} \
    ${ROS_UNRESOLVED_DEP-libfreeimage-dev} \
    ${ROS_UNRESOLVED_DEP-liboctomap-dev} \
    ${ROS_UNRESOLVED_DEP-libx11-xcb-dev} \
    ${ROS_UNRESOLVED_DEP-libxcb-randr0-dev} \
    action-msgs \
    ament-index-cpp \
    assimp \
    boost \
    builtin-interfaces \
    bullet \
    class-loader \
    composition-interfaces \
    fastcdr \
    fcl \
    fmt \
    freetype \
    geometry-msgs \
    gz-cmake-vendor \
    gz-common-vendor \
    gz-dartsim-vendor \
    gz-fuel-tools-vendor \
    gz-gui-vendor \
    gz-math-vendor \
    gz-ogre-next-vendor \
    gz-physics-vendor \
    gz-sensors-vendor \
    gz-tools-vendor \
    gz-utils-vendor \
    libccd \
    libsdl2 \
    libstatistics-collector \
    libtinyxml \
    libtinyxml2 \
    libx11 \
    libxaw \
    libxrandr \
    libyaml \
    libyaml-vendor \
    lttng-ust \
    lz4 \
    menge-vendor \
    mesa \
    message-filters \
    ode \
    poco \
    rapidjson \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-logging-implementation \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp-action \
    rclcpp-components \
    rcpputils \
    rcutils \
    rmf-door-msgs \
    rmf-lift-msgs \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-buffer \
    rosidl-buffer-backend \
    rosidl-buffer-py \
    rosidl-cmake \
    rosidl-core-runtime \
    rosidl-dynamic-typesupport \
    rosidl-generator-py \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    sdformat-vendor \
    service-msgs \
    shaderc \
    spdlog \
    spdlog-vendor \
    statistics-msgs \
    std-msgs \
    tbb \
    tf2 \
    tf2-msgs \
    tf2-ros \
    tracetools \
    type-description-interfaces \
    unique-identifier-msgs \
    urdfdom \
    vulkan-headers \
    zziplib \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-ros-core-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-package-native \
    cmake-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-native \
    python3-setuptools-native \
    rcpputils-native \
    rcutils-native \
    rosidl-buffer-native \
    rosidl-cmake-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-type-description-native \
    rosidl-pycommon-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-interface-native \
"

ROS_EXEC_DEPENDS = "\
    gz-msgs-vendor \
    gz-plugin-vendor \
    gz-rendering-vendor \
    gz-sim-vendor \
    gz-transport-vendor \
    libeigen \
    rclcpp \
    rmf-building-map-msgs \
    rmf-building-sim-gz-plugins \
    rmf-dispenser-msgs \
    rmf-fleet-msgs \
    rmf-ingestor-msgs \
    rmf-robot-sim-common \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/rmf_simulation-release/archive/release/lyrical/rmf_robot_sim_gz_plugins/2.7.0-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/rmf_robot_sim_gz_plugins"
SRC_URI = "git://github.com/ros2-gbp/rmf_simulation-release;${ROS_BRANCH};protocol=https"
SRCREV = "759acd328cd18ec0f9631c33be05aaa0d7cad7ce"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "CLI tool to evaluate the KITTI odometry bechmark metrics to trajectory files"
AUTHOR = "Jose-Luis Blanco-Claraco <joseluisblancoc@gmail.com>"
HOMEPAGE = "https://github.com/MOLAorg/mola/tree/develop/kitti_metrics_eval"
SECTION = "devel"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d0998f4eabe3d0099aca1e1f57f44fe6"

ROS_CN = "mola_academic_datasets"
ROS_BPN = "kitti_metrics_eval"

ROS_BUILD_DEPENDS = "\
    mola-common \
    mrpt-libmath \
    mrpt-libposes \
    mrpt-libtclap \
"

ROS_BUILDTOOL_DEPENDS = "\
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    mola-common \
    mrpt-libmath \
    mrpt-libposes \
    mrpt-libtclap \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    libeigen \
    mrpt-libbase \
    nanoflann-vendor \
    suitesparse-cholmod \
    suitesparse-cxsparse \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    mola-common \
    mrpt-libmath \
    mrpt-libposes \
    mrpt-libtclap \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/mola_academic_datasets-release/archive/release/lyrical/kitti_metrics_eval/3.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/kitti_metrics_eval"
SRC_URI = "git://github.com/ros2-gbp/mola_academic_datasets-release;${ROS_BRANCH};protocol=https"
SRCREV = "591da01385967c397ac1d071cdf1f4f9d2a9e6ff"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

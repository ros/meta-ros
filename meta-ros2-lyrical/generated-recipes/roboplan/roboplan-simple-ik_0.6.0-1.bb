# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "Simple inverse kinematics solver for RoboPlan."
AUTHOR = "Sebastian Castro <sebas.a.castro@gmail.com>"
HOMEPAGE = "https://roboplan.readthedocs.io"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "roboplan"
ROS_BPN = "roboplan_simple_ik"

ROS_BUILD_DEPENDS = "\
    python3 \
    python3-nanobind \
    roboplan \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    ament-cmake-python-native \
"

ROS_EXPORT_DEPENDS = "\
    roboplan \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    roboplan \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/roboplan-release/archive/release/lyrical/roboplan_simple_ik/0.6.0-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/roboplan_simple_ik"
SRC_URI = "git://github.com/ros2-gbp/roboplan-release;${ROS_BRANCH};protocol=https"
SRCREV = "8b45a75e132f284ca657bbd750d21795acb9423e"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "Demos using Gazebo Sim simulation with ROS."
AUTHOR = "Aditya Pande <adityapande@intrinsic.ai>"
ROS_AUTHOR = "Louise Poubel"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=5;endline=5;md5=3dce4ba60d7e51ec64f3c3dc18672dd3"

ROS_CN = "ros_gz"
ROS_BPN = "ros_gz_sim_demos"

ROS_BUILD_DEPENDS = "\
    gz-sim-vendor \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    gz-sim-vendor \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-glslang-dev} \
    ${ROS_UNRESOLVED_DEP-glslc} \
    ${ROS_UNRESOLVED_DEP-libfreeimage-dev} \
    ${ROS_UNRESOLVED_DEP-liboctomap-dev} \
    ${ROS_UNRESOLVED_DEP-libx11-xcb-dev} \
    ${ROS_UNRESOLVED_DEP-libxcb-randr0-dev} \
    assimp \
    boost \
    bullet \
    fcl \
    fmt \
    freetype \
    gcc-runtime \
    gz-cmake-vendor \
    gz-common-vendor \
    gz-dartsim-vendor \
    gz-fuel-tools-vendor \
    gz-gui-vendor \
    gz-math-vendor \
    gz-msgs-vendor \
    gz-ogre-next-vendor \
    gz-physics-vendor \
    gz-plugin-vendor \
    gz-rendering-vendor \
    gz-sensors-vendor \
    gz-tools-vendor \
    gz-transport-vendor \
    gz-utils-vendor \
    libccd \
    libeigen \
    libsdl2 \
    libtinyxml2 \
    libx11 \
    libxaw \
    libxrandr \
    lz4 \
    mesa \
    ode \
    poco \
    rapidjson \
    sdformat-vendor \
    shaderc \
    spdlog \
    spdlog-vendor \
    tbb \
    urdfdom \
    vulkan-headers \
    zziplib \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-package-native \
    cmake-native \
    python3-catkin-pkg-native \
    python3-setuptools-native \
"

ROS_EXEC_DEPENDS = "\
    gz-sim-vendor \
    image-transport-plugins \
    marine-acoustic-msgs \
    robot-state-publisher \
    ros-gz-bridge \
    ros-gz-image \
    ros-gz-sim \
    rqt-image-view \
    rqt-plot \
    rqt-topic \
    rviz-imu-plugin \
    rviz2 \
    sdformat-urdf \
    tf2-ros \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/ros_ign-release/archive/release/lyrical/ros_gz_sim_demos/3.0.9-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/ros_gz_sim_demos"
SRC_URI = "git://github.com/ros2-gbp/ros_ign-release;${ROS_BRANCH};protocol=https"
SRCREV = "1eccd48bd9b02ebad6715826d0e4d6028aad8103"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

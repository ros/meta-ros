# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "Fleet Adapter package for RMF fleets."
AUTHOR = "Grey <grey@openrobotics.org>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "rmf_ros2"
ROS_BPN = "rmf_fleet_adapter"

ROS_BUILD_DEPENDS = "\
    backward-ros \
    libeigen \
    nlohmann-json \
    nlohmann-json-schema-validator-vendor \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rmf-api-msgs \
    rmf-battery \
    rmf-building-map-msgs \
    rmf-dispenser-msgs \
    rmf-door-msgs \
    rmf-fleet-msgs \
    rmf-ingestor-msgs \
    rmf-lift-msgs \
    rmf-reservation-msgs \
    rmf-task \
    rmf-task-msgs \
    rmf-task-ros2 \
    rmf-task-sequence \
    rmf-traffic \
    rmf-traffic-ros2 \
    rmf-utils \
    rmf-websocket \
    std-msgs \
    yaml-cpp \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    backward-ros \
    nlohmann-json \
    nlohmann-json-schema-validator-vendor \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rmf-api-msgs \
    rmf-battery \
    rmf-building-map-msgs \
    rmf-dispenser-msgs \
    rmf-door-msgs \
    rmf-fleet-msgs \
    rmf-ingestor-msgs \
    rmf-lift-msgs \
    rmf-reservation-msgs \
    rmf-task \
    rmf-task-msgs \
    rmf-task-ros2 \
    rmf-task-sequence \
    rmf-traffic \
    rmf-traffic-ros2 \
    rmf-utils \
    rmf-websocket \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    action-msgs \
    ament-index-cpp \
    builtin-interfaces \
    class-loader \
    composition-interfaces \
    elfutils \
    fastcdr \
    libccd \
    libstatistics-collector \
    libyaml \
    libyaml-vendor \
    lttng-ust \
    proj \
    python3-jinja2 \
    python3-jsonschema \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-logging-implementation \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rcpputils \
    rcutils \
    rmf-site-map-msgs \
    rmf-traffic-msgs \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-buffer \
    rosidl-buffer-backend \
    rosidl-buffer-py \
    rosidl-cmake \
    rosidl-core-runtime \
    rosidl-dynamic-typesupport \
    rosidl-generator-py \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    service-msgs \
    statistics-msgs \
    tracetools \
    type-description-interfaces \
    unique-identifier-msgs \
    zlib \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-ros-core-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-package-native \
    cmake-native \
    eigen3-cmake-module-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-native \
    python3-setuptools-native \
    rcpputils-native \
    rcutils-native \
    rosidl-buffer-native \
    rosidl-cmake-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-type-description-native \
    rosidl-pycommon-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-interface-native \
"

ROS_EXEC_DEPENDS = "\
    backward-ros \
    nlohmann-json \
    nlohmann-json-schema-validator-vendor \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rmf-api-msgs \
    rmf-battery \
    rmf-building-map-msgs \
    rmf-dispenser-msgs \
    rmf-door-msgs \
    rmf-fleet-msgs \
    rmf-ingestor-msgs \
    rmf-lift-msgs \
    rmf-reservation-msgs \
    rmf-task \
    rmf-task-msgs \
    rmf-task-ros2 \
    rmf-task-sequence \
    rmf-traffic \
    rmf-traffic-ros2 \
    rmf-utils \
    rmf-websocket \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-catch2 \
    ament-cmake-uncrustify \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/rmf_ros2-release/archive/release/lyrical/rmf_fleet_adapter/2.13.0-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/rmf_fleet_adapter"
SRC_URI = "git://github.com/ros2-gbp/rmf_ros2-release;${ROS_BRANCH};protocol=https"
SRCREV = "b6b0fa76f2480726f9111572fd4626c92840645f"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

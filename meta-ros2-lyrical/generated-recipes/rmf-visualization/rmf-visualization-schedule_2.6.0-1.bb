# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "A visualizer for trajectories in rmf schedule"
AUTHOR = "Yadunund <yadunund@openrobotics.org>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "rmf_visualization"
ROS_BPN = "rmf_visualization_schedule"

ROS_BUILD_DEPENDS = "\
    boost \
    builtin-interfaces \
    geometry-msgs \
    libeigen \
    openssl \
    rclcpp \
    rclcpp-components \
    rmf-traffic \
    rmf-traffic-msgs \
    rmf-traffic-ros2 \
    rmf-visualization-msgs \
    rosidl-default-generators \
    visualization-msgs \
    websocketpp \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    boost \
    builtin-interfaces \
    geometry-msgs \
    libeigen \
    openssl \
    rclcpp \
    rclcpp-components \
    rmf-traffic \
    rmf-traffic-msgs \
    rmf-traffic-ros2 \
    rmf-visualization-msgs \
    rosidl-default-generators \
    visualization-msgs \
    websocketpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ament-index-cpp \
    backward-ros \
    class-loader \
    composition-interfaces \
    elfutils \
    fastcdr \
    gcc-runtime \
    libccd \
    libstatistics-collector \
    libyaml \
    libyaml-vendor \
    lttng-ust \
    nlohmann-json \
    proj \
    rcl \
    rcl-interfaces \
    rcl-logging-implementation \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rcpputils \
    rcutils \
    rmf-building-map-msgs \
    rmf-fleet-msgs \
    rmf-reservation-msgs \
    rmf-site-map-msgs \
    rmf-utils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-buffer \
    rosidl-buffer-backend \
    rosidl-buffer-py \
    rosidl-cmake \
    rosidl-core-runtime \
    rosidl-dynamic-typesupport \
    rosidl-generator-py \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    sensor-msgs \
    service-msgs \
    statistics-msgs \
    std-msgs \
    tracetools \
    type-description-interfaces \
    yaml-cpp \
    zlib \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    action-msgs-native \
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-ros-core-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-package-native \
    builtin-interfaces-native \
    cmake-native \
    eigen3-cmake-module-native \
    fastcdr-native \
    gcc-runtime-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-native \
    python3-setuptools-native \
    rcpputils-native \
    rcutils-native \
    rmw-native \
    ros-environment-native \
    rosidl-buffer-backend-native \
    rosidl-buffer-native \
    rosidl-buffer-py-native \
    rosidl-cmake-native \
    rosidl-core-generators-native \
    rosidl-core-runtime-native \
    rosidl-dynamic-typesupport-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-py-native \
    rosidl-generator-rs-native \
    rosidl-generator-type-description-native \
    rosidl-pycommon-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-cpp-native \
    rosidl-typesupport-fastrtps-c-native \
    rosidl-typesupport-fastrtps-cpp-native \
    rosidl-typesupport-interface-native \
    rosidl-typesupport-introspection-c-native \
    rosidl-typesupport-introspection-cpp-native \
    service-msgs-native \
    unique-identifier-msgs-native \
"

ROS_EXEC_DEPENDS = "\
    boost \
    builtin-interfaces \
    geometry-msgs \
    libeigen \
    openssl \
    rclcpp \
    rclcpp-components \
    rmf-traffic \
    rmf-traffic-msgs \
    rmf-traffic-ros2 \
    rmf-visualization-msgs \
    rosidl-default-generators \
    visualization-msgs \
    websocketpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-uncrustify \
    ament-lint-auto \
    ament-lint-common \
    rmf-utils \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/rmf_visualization-release/archive/release/lyrical/rmf_visualization_schedule/2.6.0-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/rmf_visualization_schedule"
SRC_URI = "git://github.com/ros2-gbp/rmf_visualization-release;${ROS_BRANCH};protocol=https"
SRCREV = "c575945f86125c07d022c4f05a94e50992fe225e"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_lyrical
inherit ros_superflore_generated

DESCRIPTION = "A package to visualiize the navigation graphs of fleets"
AUTHOR = "Yadunund <yadunund@openrobotics.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache license 2.0"
LICENSE = "Apache-license-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=f732ed9bfcfc284137bfb375329922e3"

ROS_CN = "rmf_visualization"
ROS_BPN = "rmf_visualization_navgraphs"

ROS_BUILD_DEPENDS = "\
    geometry-msgs \
    rclcpp \
    rclcpp-components \
    rmf-building-map-msgs \
    rmf-fleet-msgs \
    rmf-traffic \
    rmf-traffic-ros2 \
    rmf-visualization-msgs \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    geometry-msgs \
    rclcpp \
    rclcpp-components \
    rmf-building-map-msgs \
    rmf-fleet-msgs \
    rmf-traffic \
    rmf-traffic-ros2 \
    rmf-visualization-msgs \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ament-index-cpp \
    backward-ros \
    builtin-interfaces \
    class-loader \
    composition-interfaces \
    elfutils \
    fastcdr \
    libccd \
    libeigen \
    libstatistics-collector \
    libyaml \
    libyaml-vendor \
    lttng-ust \
    nlohmann-json \
    proj \
    rcl \
    rcl-interfaces \
    rcl-logging-implementation \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rcpputils \
    rcutils \
    rmf-reservation-msgs \
    rmf-site-map-msgs \
    rmf-traffic-msgs \
    rmf-utils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-buffer \
    rosidl-buffer-backend \
    rosidl-buffer-py \
    rosidl-cmake \
    rosidl-core-runtime \
    rosidl-dynamic-typesupport \
    rosidl-generator-py \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    sensor-msgs \
    service-msgs \
    statistics-msgs \
    std-msgs \
    tracetools \
    type-description-interfaces \
    yaml-cpp \
    zlib \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-ros-core-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-package-native \
    cmake-native \
    eigen3-cmake-module-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-native \
    python3-setuptools-native \
    rcpputils-native \
    rcutils-native \
    rosidl-buffer-native \
    rosidl-cmake-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-type-description-native \
    rosidl-pycommon-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-interface-native \
"

ROS_EXEC_DEPENDS = "\
    geometry-msgs \
    rclcpp \
    rclcpp-components \
    rmf-building-map-msgs \
    rmf-fleet-msgs \
    rmf-traffic \
    rmf-traffic-ros2 \
    rmf-visualization-msgs \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
    rmf-utils \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/rmf_visualization-release/archive/release/lyrical/rmf_visualization_navgraphs/2.6.0-1.tar.gz
ROS_BRANCH ?= "branch=release/lyrical/rmf_visualization_navgraphs"
SRC_URI = "git://github.com/ros2-gbp/rmf_visualization-release;${ROS_BRANCH};protocol=https"
SRCREV = "d3d4e20d7e8ba48e79ba469e7a4fe5073fb67501"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILD_DEPENDS_remove = " \
    tracetools \
"
ROS_EXPORT_DEPENDS_remove = " \
    tracetools \
"
ROS_EXEC_DEPENDS_remove = " \
    tracetools \
"

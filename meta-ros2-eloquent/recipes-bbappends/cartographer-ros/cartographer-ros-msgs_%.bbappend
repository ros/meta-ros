# Copyright (c) 2020 LG Electronics, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    rosidl-parser-native \
    python3-numpy-native \
    python3-lark-parser-native \
"

# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILD_DEPENDS_remove = " \
    rcl-logging-spdlog \
"
ROS_EXPORT_DEPENDS_remove = " \
    rcl-logging-spdlog \
"
ROS_EXEC_DEPENDS_remove = " \
    rcl-logging-spdlog \
"

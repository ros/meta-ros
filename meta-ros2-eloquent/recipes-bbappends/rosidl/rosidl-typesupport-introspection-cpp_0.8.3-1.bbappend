# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILD_DEPENDS:append = " \
    rosidl-generator-c \
"

# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILD_DEPENDS_append = " \
    rosidl-generator-c \
"

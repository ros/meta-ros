# Copyright (c) 2020 LG Electronics, Inc.

FILES_${PN} += "${datadir}/costmap_plugins.xml ${datadir}/example"

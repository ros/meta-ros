# Copyright (c) 2019 LG Electronics, Inc.

# spdlog is header only library and PN is empty, so it wasn't created
RDEPENDS:${PN}:remove = "spdlog"

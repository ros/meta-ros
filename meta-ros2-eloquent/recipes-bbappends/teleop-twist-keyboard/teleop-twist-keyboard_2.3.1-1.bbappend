# Copyright (c) 2019-2020 LG Electronics, Inc.

# What's in package.xml doesn't match what's in LICENSE.
LICENSE = "BSD-3-Clause"

# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    rosidl-adapter-native \
    rosidl-parser-native \
    python3-numpy-native \
    python3-lark-parser-native \
"
RROS_BUILDTOOL_DEPENDS += " \
    rosidl-default-generators-native \
    python3-empy-native \
"

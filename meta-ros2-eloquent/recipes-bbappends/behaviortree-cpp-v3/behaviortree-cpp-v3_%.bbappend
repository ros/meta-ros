# Copyright (c) 2020 LG Electronics, Inc.

FILES:${PN}-dev:prepend = " \
    ${libdir}/BehaviorTreeV3/cmake \
"

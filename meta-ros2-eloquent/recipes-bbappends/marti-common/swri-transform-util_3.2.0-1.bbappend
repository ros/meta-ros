# Copyright (c) 2020 LG Electronics, Inc.

# Needed for proj-6
CXXFLAGS += "-DACCEPT_USE_OF_DEPRECATED_PROJ_API_H"

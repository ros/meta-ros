# Copyright (c) 2020 LG Electronics, Inc.

FILES_${PN} += "${prefix}/launch"

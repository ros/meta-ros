# Copyright (c) 2019-2020 LG Electronics, Inc.

ALLOW_EMPTY_${PN} = "1"

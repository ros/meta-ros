# Copyright (c) 2019-2020 LG Electronics, Inc.

# Missing license version in package.xml
# https://github.com/ros2-gbp/orocos_kinematics_dynamics-release/issues/2
LICENSE = "LGPL-2.1"

# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    python-cmake-module-native \
    python3-empy-native \
    python3-lark-parser-native \
    python3-numpy-native \
    rosidl-adapter-native \
    rosidl-generator-cpp-native \
    rosidl-generator-py-native \
    rosidl-parser-native \
    rosidl-typesupport-cpp-native \
"

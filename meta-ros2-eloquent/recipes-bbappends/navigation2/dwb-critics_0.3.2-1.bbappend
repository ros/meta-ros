# Copyright (c) 2020 LG Electronics, Inc.

FILES_${PN} += "${datadir}/default_critics.xml"

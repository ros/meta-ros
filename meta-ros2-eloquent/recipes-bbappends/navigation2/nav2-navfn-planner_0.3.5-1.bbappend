# Copyright (c) 2020 LG Electronics, Inc.

FILES:${PN}:prepend = " \
    ${datadir}/global_planner_plugin.xml \
"

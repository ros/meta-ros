# Copyright (c) 2020 LG Electronics, Inc.

FILES:${PN} += "${datadir}/plugins.xml"

# Copyright (c) 2019 LG Electronics, Inc.

ROS_EXEC_DEPENDS:remove = "python-numpy"
ROS_EXEC_DEPENDS:append = " python3-numpy"

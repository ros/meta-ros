# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    python3-lark-parser-native \
    python3-numpy-native \
    rosidl-parser-native \
"

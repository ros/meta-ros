# Copyright (c) 2019 LG Electronics, Inc.

FILES:${PN}-doc:prepend = "${datadir}/licenses "

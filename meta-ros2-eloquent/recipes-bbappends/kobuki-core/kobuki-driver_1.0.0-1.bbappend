# Copyright (c) 2020 LG Electronics, Inc.

inherit ros-insane
# ERROR: QA Issue: non -dev/-dbg/nativesdk- package contains symlink .so: kobuki-driver path '/work/core2-64-oe-linux/kobuki-driver/1.0.0-1-r0/packages-split/kobuki-driver/usr/lib/libkobuki_driver.so' [dev-so]

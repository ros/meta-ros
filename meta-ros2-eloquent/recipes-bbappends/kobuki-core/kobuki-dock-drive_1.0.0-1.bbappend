# Copyright (c) 2020 LG Electronics, Inc.

inherit ros-insane
# ERROR: QA Issue: non -dev/-dbg/nativesdk- package contains symlink .so: kobuki-dock-drive path '/work/core2-64-oe-linux/kobuki-dock-drive/1.0.0-1-r0/packages-split/kobuki-dock-drive/usr/lib/libkobuki_dock_drive.so' [dev-so]

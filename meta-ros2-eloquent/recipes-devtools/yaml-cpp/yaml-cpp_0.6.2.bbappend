# Copyright (c) 2019 LG Electronics, Inc.

# This is the commit that the yaml-cpp-vendor v7.0.0-1 ExternalProject builds.
SRCREV = "0f9a586ca1dc29c2ecb8dd715a315b93e3f40f79"
PV .= "+git${SRCPV}"

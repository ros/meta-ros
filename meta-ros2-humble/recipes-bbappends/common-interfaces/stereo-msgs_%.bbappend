# Copyright (c) 2023 Wind River Systems, Inc.

EXTRA_OECMAKE += " -DPYTHON_INSTALL_DIR=${baselib}/${PYTHON_DIR}/site-packages"

# Copyright (c) 2022 Wind River Systems, Inc.

FILES:${PN} += "${datadir}/licenses/COPYING \
                ${datadir}/licenses/AUTHORS \
                ${datadir}/licenses/COPYING-PLAIN"

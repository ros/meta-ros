# Copyright (c) 2023 Wind River Systems, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    eigen3-cmake-module \
    rosidl-default-generators-native \
"

LICENSE = "LGPL-2.1-or-later"

<<<<<<< HEAD
ROS_BUILDTOOL_DEPENDS += " \
    rosidl-adapter-native \
    generate-parameter-library-py-native \
"
=======
# Copyright (c) 2023 Wind River Systems, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    rosidl-default-generators-native \
    generate-parameter-library-py-native \
"
>>>>>>> upstream/kirkstone

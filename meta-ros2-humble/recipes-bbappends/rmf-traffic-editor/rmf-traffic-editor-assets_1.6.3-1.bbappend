# Copyright (c) 2021 LG Electronics, Inc.

#   /usr/share/assets/thumbnails/model_list.yaml
#   /usr/share/assets/thumbnails/images
#   /usr/share/assets/thumbnails/images/cropped
#   /usr/share/assets/thumbnails/images/cropped/OpenRobotics
#   /usr/share/assets/thumbnails/images/cropped/OpenRobotics/VisitorKidSit.png
#   .. a lot of .png files here ..
FILES:${PN} += "${datadir}/assets"

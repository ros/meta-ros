# Copyright (c) 2020 LG Electronics, Inc.

DEPENDS += "python3-pybind11"
RDEPENDS:${PN} += "python3-pybind11"
ALLOW_EMPTY:${PN} = "1"

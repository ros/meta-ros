inherit ros_ament_cmake

ROS_BUILDTOOL_DEPENDS:append = " \
    eigen3-cmake-module-native \
"

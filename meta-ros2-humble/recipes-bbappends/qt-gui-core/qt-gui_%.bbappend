LICENSE = "BSD-3-Clause"

inherit setuptools3-base

# Copyright (c) 2023 Wind River Systems, Inc.

LICENSE = "BSD-3-Clause"

DEPENDS += "sip-native python3-pyqt5-native"

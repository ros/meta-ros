# Copyright (c) 2024 Wind River Systems, Inc.

inherit pkgconfig

ROS_BUILD_DEPENDS += " \
    rosidl-adapter-native \
"

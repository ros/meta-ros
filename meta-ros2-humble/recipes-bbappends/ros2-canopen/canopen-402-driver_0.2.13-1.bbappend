LICENSE = "LGPL-3.0-only"

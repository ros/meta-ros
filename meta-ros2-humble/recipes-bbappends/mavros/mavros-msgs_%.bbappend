LICENSE = "GPL-3.0-only & LGPL-3.0-only & BSD-3-Clause"

# Copyright (c) 2023 Wind River Systems, Inc.

inherit pkgconfig

LICENSE = "Apache-2.0"

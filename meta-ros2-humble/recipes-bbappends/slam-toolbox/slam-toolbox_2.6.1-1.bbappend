# Copyright (c) 2022 Wind River Systems, Inc.

# Doesn't need runtime dependency on ceres-solver
ROS_EXEC_DEPENDS:remove = "ceres-solver"

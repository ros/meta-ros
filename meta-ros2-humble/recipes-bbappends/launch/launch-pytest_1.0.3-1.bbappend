# Copyright (c) 2022 Wind River Systems, Inc.

FILES:${PN} += "${datadir}/lib/${ROS_BPN}"

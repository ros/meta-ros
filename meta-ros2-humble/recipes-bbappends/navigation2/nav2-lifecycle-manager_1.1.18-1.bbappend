# Copyright (c) 2022 Wind River Systems, Inc.

# nav2-lifecycle-manager/1.1.2-1-r0/recipe-sysroot/usr/include/nav2_msgs/nav2_msgs/srv/detail/manage_lifecycle_nodes__struct.hpp:137:19: error: redundant redeclaration of 'constexpr' static data member 'nav2_msgs::srv::ManageLifecycleNodes_Request_<ContainerAllocator>::STARTUP' [-Werror=deprecated]
CXXFLAGS += "-Wno-error=deprecated"

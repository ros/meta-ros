ROS_BUILDTOOL_DEPENDS:append = " \
    rosidl-adapter-native \
    ament-cmake-ros-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-py-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-cpp-native \
    rosidl-typesupport-fastrtps-c-native \
    rosidl-typesupport-fastrtps-cpp-native \
    python-cmake-module-native \
"

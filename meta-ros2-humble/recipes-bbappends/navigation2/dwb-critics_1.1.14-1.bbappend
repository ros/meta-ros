# Copyright (c) 2024 Wind River Systems, Inc.

# dwb-critics/1.1.12-1/recipe-sysroot/usr/include/rclcpp/rclcpp/parameter.hpp:70:21: error: 'value' may be used uninitialized [-Werror=maybe-uninitialized]
CXXFLAGS += "-Wno-error=maybe-uninitialized"

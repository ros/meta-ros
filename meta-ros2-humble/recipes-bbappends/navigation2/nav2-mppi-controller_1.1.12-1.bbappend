# Copyright (c) 2023 Wind River Systems, Inc.

ROS_EXEC_DEPENDS:remove = "${ROS_UNRESOLVED_DEP-xsimd}"
ROS_EXEC_DEPENDS:remove = "${ROS_UNRESOLVED_DEP-xtensor}"

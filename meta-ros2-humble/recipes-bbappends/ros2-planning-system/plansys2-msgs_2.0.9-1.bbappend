ROS_BUILDTOOL_DEPENDS:append = " \
    rosidl-default-generators-native \
"

ROS_BUILD_DEPENDS:remove = " \
    rosidl-default-generators-native \
"

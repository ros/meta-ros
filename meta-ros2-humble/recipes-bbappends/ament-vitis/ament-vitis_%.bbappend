# Copyright (c) 2022 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += " \
  ament-cmake-gmock-native \
  ament-cmake-gtest-native \
  ament-cmake-pytest-native \
  ament-cmake-test-native \
  ament-cmake-libraries \
  ament-cmake-native \
"

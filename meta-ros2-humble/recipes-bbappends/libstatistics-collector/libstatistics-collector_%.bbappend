# Copyright (c) 2022 Acceleration Robotics S.L. <contact@accelerationrobotics.com>

ROS_BUILD_DEPENDS += " \
    python3-numpy-native \
"

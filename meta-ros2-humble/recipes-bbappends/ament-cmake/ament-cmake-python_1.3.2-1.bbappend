FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-ament_python_install_package-exclude-libraries-from-.patch \
"
# Copyright (c) 2022 Acceleration Robotics S.L. <contact@accelerationrobotics.com>

FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += " \
    file://0001-Manually-add-CMake-macros-from-hoofs-and-posh.patch \
"
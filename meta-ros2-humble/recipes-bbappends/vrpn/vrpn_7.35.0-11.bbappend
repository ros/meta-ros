# Copyright (c) 2022 Wind River Systems, Inc.
FILES:${PN}-dev += "${datadir}/quatlib/cmake/*.cmake"

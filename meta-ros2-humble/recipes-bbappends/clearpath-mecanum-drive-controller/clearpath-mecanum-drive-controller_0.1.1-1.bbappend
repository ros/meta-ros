# Copyright (c) 2025 Wind River Systems, Inc.

ROS_BUILD_DEPENDS = " \
    backward-ros \
    rsl \
"

ROS_BUILDTOOL_DEPENDS += " \
    generate-parameter-library-native \
"

# Copyright (c) 2023 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += " \
    pid-controller \
"

ROS_BUILDTOOL_DEPENDS += " \
    ament-cmake-ros-native \
"

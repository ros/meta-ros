# fixing qa [dev-so]
FILES:${PN}-dev += " \
    /usr/lib/libsrdfdom.so \
"

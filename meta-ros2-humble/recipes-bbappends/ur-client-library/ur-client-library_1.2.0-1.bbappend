# Copyright (c) 2022 Wind River Systems, Inc.

FILES:${PN} += "${datadir}/ament_index/resource_index/packages/ur_client_library"

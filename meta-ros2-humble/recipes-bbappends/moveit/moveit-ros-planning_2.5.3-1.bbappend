# fixing qa [dev-so]
FILES:${PN}-dev += " \
    ${libdir}/lib*.so \
"

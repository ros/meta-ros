# fix qa [dev-so]
FILES:${PN}-dev += " \
    ${libdir}/*.so \
"

# fixing qa [dev-so]
FILES:${PN}-dev += " \
    ${libdir}/libmoveit_common_planning_interface_objects.so \
    ${libdir}/libmoveit_planning_scene_interface.so \
    ${libdir}/libmoveit_move_group_interface.so \
"
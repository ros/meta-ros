# Copyright (c) 2022 Wind River Systems, Inc.

FILES:${PN}-dev += "${libdir}/libmoveit_chomp_optimizer_adapter.so"

# fixing qa [dev-so]
FILES:${PN}-dev += " \
    /usr/lib/libmoveit_warehouse.so \
"
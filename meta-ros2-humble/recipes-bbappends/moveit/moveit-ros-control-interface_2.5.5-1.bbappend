# Copyright (c) 2021 LG Electronics, Inc.

# ERROR: moveit-ros-control-interface-2.3.0-1-r0 do_package_qa: QA Issue:
# non -dev/-dbg/nativesdk- package moveit-ros-control-interface contains symlink .so '/usr/lib/libmoveit_ros_control_interface_trajectory_plugin.so'
# non -dev/-dbg/nativesdk- package moveit-ros-control-interface contains symlink .so '/usr/lib/libmoveit_ros_control_interface_plugin.so'
# non -dev/-dbg/nativesdk- package moveit-ros-control-interface contains symlink .so '/usr/lib/libmoveit_ros_control_interface_gripper_plugin.so' [dev-so]
inherit ros_insane_dev_so

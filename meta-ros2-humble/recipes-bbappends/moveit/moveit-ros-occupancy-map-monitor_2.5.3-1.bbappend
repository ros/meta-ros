# fixes qa [dev-so]
FILES:${PN}-dev += " \
    /usr/lib/libmoveit_ros_occupancy_map_monitor.so \
"
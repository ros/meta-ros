# Copyright (c) 2022 Wind River Systems, Inc.

DEPENDS += "python3-pybind11-json"

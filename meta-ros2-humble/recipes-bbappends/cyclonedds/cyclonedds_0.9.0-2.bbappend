FILES:${PN}-dev += " \
    ${libdir}/libddsc.so \
    ${libdir}/libddsc.so.0 \
"
RDEPENDS:${PN} += "python3-core"
ROS_BUILD_DEPENDS = " \
    libphidget22-upstream \
"
# Copyright (c) 2019 LG Electronics, Inc.
# Copyright (c) 2022 Acceleration Robotics S.L. <contact@accelerationrobotics.com>

inherit ros_insane_dev_so

# for rosidl-typesupport-fastrtps-c-native
BBCLASSEXTEND = "native"

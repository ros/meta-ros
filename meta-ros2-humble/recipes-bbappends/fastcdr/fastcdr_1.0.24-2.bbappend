
FILES:${PN}-dev += " \
    ${libdir}/libfastcdr.so \
    ${libdir}/libfastcdr.so.1 \
"

BBCLASSEXTEND = "native"
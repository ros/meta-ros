# Copyright (C) 2023 Advanced Micro Devices, Inc.  All rights reserved.

FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://0001-Add-in-a-missing-cstdint-include.-1321-1322.patch"
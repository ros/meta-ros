# Copyright (c) 2019-2021 LG Electronics, Inc.

#ROS_BUILDTOOL_DEPENDS += " \
#    fastcdr-native \
#    rosidl-cmake-native \
#    rosidl-runtime-c-native \
#    rosidl-runtime-cpp-native \
#    rosidl-parser-native \
#"

# ROS_BUILDTOOL_EXPORT_DEPENDS:remove = "rosidl-generator-cpp-native"
# ROS_BUILDTOOL_EXPORT_DEPENDS:remove = "fastrtps-cmake-module-native"

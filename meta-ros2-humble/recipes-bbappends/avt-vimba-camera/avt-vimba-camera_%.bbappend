# Copyright (c) 2022 Wind River Systems, Inc.

INSANE_SKIP:${PN} += "already-stripped"

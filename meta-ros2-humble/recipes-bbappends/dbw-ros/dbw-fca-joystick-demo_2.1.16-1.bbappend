# Copyright (c) 2023 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += " \
    rclcpp-components \
"

LICENSE = "BSD-3-Clause"

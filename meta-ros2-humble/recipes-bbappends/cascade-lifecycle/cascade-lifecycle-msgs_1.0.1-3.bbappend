ROS_BUILDTOOL_DEPENDS:append = " \
    rosidl-default-generators-native \
    rosidl-adapter-native \
    ament-cmake-ros-native \
    python-cmake-module-native \
"
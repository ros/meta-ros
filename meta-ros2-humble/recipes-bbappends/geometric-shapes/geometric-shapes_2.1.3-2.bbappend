# fixes [dev-so] qa issue
FILES:${PN}-dev += " \
    /usr/lib/libgeometric_shapes.so \
"
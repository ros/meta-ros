#Copyright (c) Qualcomm Innovation Center, Inc. All rights reserved

#compressed-depth-image-transport/2.5.1-1-r0/recipe-sysroot/usr/include/rcutils/rcutils/logging_macros.h:79:18: error: format not a string literal and no format arguments [-Werror=format-security]
CXXFLAGS += "-Wno-format-security"
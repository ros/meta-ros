FILES:${PN} += "${datadir}/lib"

# Copyright (c) 2021 LG Electronics, Inc.

ROS_BUILD_DEPENDS:remove = "rosidl-default-generators"

# ROS_BUILDTOOL_DEPENDS += " \
#    rosidl-typesupport-fastrtps-c-native \
#    rosidl-typesupport-fastrtps-cpp-native \
#"

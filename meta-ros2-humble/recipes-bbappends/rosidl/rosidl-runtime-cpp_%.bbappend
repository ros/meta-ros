# Copyright (c) 2022 Acceleration Robotics, S.L.

BBCLASSEXTEND =+ "native"

# Copyright (c) 2022 Acceleration Robotics S.L. <contact@accelerationrobotics.com>

# for rosidl-generator-py-native
BBCLASSEXTEND = "native"
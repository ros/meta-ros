# Copyright (c) 2022, Wind River Systems, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    rosidl-cmake-native \
"

SRC_URI = "git://github.com/ros2-gbp/game_controller_spl-release;${ROS_BRANCH};protocol=https"

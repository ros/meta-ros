ROS_BUILD_DEPENDS:append = " \
    fastrtps-cmake-module \
    fastcdr \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-generator-c \
    rosidl-generator-cpp \
"
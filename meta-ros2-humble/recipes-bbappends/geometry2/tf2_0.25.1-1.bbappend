# Copyright (c) 2020 LG Electronics, Inc.
# Copyright (c) 2022 Wind River Systems, Inc.

DEPENDS += "rosidl-cmake"

ROS_BUILDTOOL_DEPENDS = " \
    rosidl-generator-py-native \
"

# Copyright (c) 2024 Wind River Systems, Inc.

EXTRA_OECMAKE = "-DSERIAL_INCLUDE_DIRS=${STAGING_INCDIR}/libserial -DSERIAL_LDFLAGS=-lserial"

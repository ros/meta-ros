# websocketpp does not provide runtime components
ROS_EXEC_DEPENDS:remove += "websocketpp"


ROS_BUILD_DEPENDS:append = " \
    python3-numpy \
    rosidl-generator-py \
"

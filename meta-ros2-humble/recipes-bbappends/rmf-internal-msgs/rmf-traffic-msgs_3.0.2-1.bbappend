# Copyright (c) 2021 LG Electronics, Inc.
# Copyright (c) 2022 Wind River Systems, Inc.

SRCREV = "5241159d84c4c2956a869037a934cab9401edf06"

ROS_BUILD_DEPENDS += " \
    fastcdr \
    fastrtps \
    fastrtps-cmake-module \
    rosidl-default-runtime \
    rosidl-default-generators \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-introspection-cpp \
    rosidl-typesupport-fastrtps-c-native \
    rosidl-typesupport-fastrtps-cpp-native \
"

# avoid [installed-vs-shipped] of /usr/share/ament_index
inherit ros_ament_cmake
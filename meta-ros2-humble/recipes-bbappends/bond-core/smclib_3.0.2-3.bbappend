EXTRA_OECMAKE += " -DPYTHON_INSTALL_DIR=${PYTHON_SITEPACKAGES_DIR} "

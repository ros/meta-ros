# Copyright (c) 2022 Wind River Systems, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    pkgconfig-native \
"

ROS_BUILD_DEPENDS += " \
    eigen3-cmake-module \
    rmf-site-map-msgs \
    rmf-building-map-msgs \
    nlohmann-json \
    proj \
"

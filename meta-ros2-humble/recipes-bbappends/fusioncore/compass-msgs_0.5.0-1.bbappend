# Copyright (c) 2026 Wind River Systems, Inc.

# package.xml declares "BSD" but the package only ships Apache-2.0 license
# text, so both are listed.
LICENSE = "Apache-2.0 AND BSD-3-Clause"

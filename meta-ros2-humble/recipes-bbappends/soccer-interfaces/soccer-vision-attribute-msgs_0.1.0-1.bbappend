ROS_BUILD_DEPENDS:append = " \
    rosidl-generator-py \
"

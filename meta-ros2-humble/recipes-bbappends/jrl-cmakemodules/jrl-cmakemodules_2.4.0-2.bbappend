# Copyright (c) 2026 Wind River Systems, Inc.

LICENSE = "GPL-3.0-or-later & LGPL-3.0-or-later & BSD-3-Clause & MIT & Apache-2.0"

RDEPENDS:${PN} += "bash"

# Copyright (c) 2026 Wind River Systems, Inc.


RDEPENDS:${PN} += "bash"

# Copyright (c) 2023 Wind River Systems, Inc.

LICENSE = "Apache-2.0"

ROS_BUILDTOOL_DEPENDS += " \
    ament-cmake-ros-native \ 
    python3-numpy-native \
    rosidl-adapter-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-py-native \
    rosidl-typesupport-fastrtps-c-native \
    rosidl-typesupport-fastrtps-cpp-native \
    rosidl-typesupport-introspection-cpp-native \
    rosidl-typesupport-cpp-native \
"

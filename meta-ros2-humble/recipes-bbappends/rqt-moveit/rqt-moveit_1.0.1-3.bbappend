# Copyright (c) 2024 Wind River Systems, Inc.

FILES:${PN} += "${datadir}/lib/rqt_moveit"

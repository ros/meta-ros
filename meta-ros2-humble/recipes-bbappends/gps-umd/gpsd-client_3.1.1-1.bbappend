# Copyright (c) 2021 LG Electronics, Inc.

LICENSE = "BSD-3-Clause"

inherit pkgconfig

# Copyright (c) 2021 LG Electronics, Inc.

inherit pkgconfig

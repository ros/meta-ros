# Copyright (c) 2026 Wind River Systems, Inc.

LICENSE = "MPL-2.0"

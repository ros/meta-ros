# Copyright (c) 2024 Wind River Systems, Inc.

FILES:${PN}lib += "${libdir}/libgeos.so.*"

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "bcr_bot"
AUTHOR = "Gaurav Gupta <gaurav@blackcoffeerobotics.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "(C) Black Coffee Robotics"
LICENSE = "-C-Black-Coffee-Robotics"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=f132ad0c87b169f04bee1963990e7d76"

ROS_CN = "bcr_bot"
ROS_BPN = "bcr_bot"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ament-index-python \
    launch \
    launch-ros \
    robot-state-publisher \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-gtest \
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/blackcoffeerobotics/bcr_bot_ros2-release/archive/release/humble/bcr_bot/1.0.1-3.tar.gz
ROS_BRANCH ?= "branch=release/humble/bcr_bot"
SRC_URI = "git://github.com/blackcoffeerobotics/bcr_bot_ros2-release;${ROS_BRANCH};protocol=https"
SRCREV = "0e414426b9bf046d4f214b704316bb3cfa429876"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

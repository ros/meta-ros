# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "A multiplexer and demultiplexer between common dbw messages and platform specific dbw messages."
AUTHOR = "Kevin Hallenbeck <khallenbeck@dataspeedinc.com>"
ROS_AUTHOR = "Robert Maupin <rmaupin@dataspeedinc.com>"
HOMEPAGE = "http://dataspeedinc.com"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "dbw_ros"
ROS_BPN = "dataspeed_dbw_gateway"

ROS_BUILD_DEPENDS = " \
    dataspeed-dbw-common \
    dataspeed-dbw-msgs \
    dbw-fca-msgs \
    dbw-ford-msgs \
    dbw-polaris-msgs \
    diagnostic-msgs \
    rclcpp \
    rclcpp-components \
    ros-environment \
    rosidl-default-generators \
    sensor-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-ros-native \
"

ROS_EXPORT_DEPENDS = " \
    dataspeed-dbw-common \
    dataspeed-dbw-msgs \
    dbw-fca-msgs \
    dbw-ford-msgs \
    dbw-polaris-msgs \
    diagnostic-msgs \
    rclcpp \
    rclcpp-components \
    ros-environment \
    sensor-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    dataspeed-dbw-common \
    dataspeed-dbw-msgs \
    dbw-fca-msgs \
    dbw-ford-msgs \
    dbw-polaris-msgs \
    diagnostic-msgs \
    rclcpp \
    rclcpp-components \
    ros-environment \
    rosidl-default-runtime \
    sensor-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-gtest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/DataspeedInc-release/dbw_ros-release/archive/release/humble/dataspeed_dbw_gateway/2.1.3-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/dataspeed_dbw_gateway"
SRC_URI = "git://github.com/DataspeedInc-release/dbw_ros-release;${ROS_BRANCH};protocol=https"
SRCREV = "bffb4a737633ca2f3980d3e271f214093053675d"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

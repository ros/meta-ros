# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "ROS Foxglove Bridge"
AUTHOR = "Foxglove <ros-tooling+foxglove_bridge@foxglove.dev>"
ROS_AUTHOR = "Foxglove <ros-tooling+foxglove_bridge@foxglove.dev>"
HOMEPAGE = "https://github.com/foxglove/foxglove-sdk"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=6;endline=6;md5=92566b45c3390e5178465bcaade208b7"

ROS_CN = "foxglove-sdk"
ROS_BPN = "foxglove_bridge"

ROS_BUILD_DEPENDS = " \
    ament-index-cpp \
    geometry-msgs \
    rcl-interfaces \
    rclcpp \
    rclcpp-components \
    rcpputils \
    rcutils \
    resource-retriever \
    ros-environment \
    rosgraph-msgs \
    rosidl-typesupport-introspection-cpp \
    rosx-introspection \
    sensor-msgs \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    ament-index-cpp \
    rcl-interfaces \
    rclcpp \
    rclcpp-components \
    rcpputils \
    rcutils \
    resource-retriever \
    rosgraph-msgs \
    rosidl-typesupport-introspection-cpp \
    rosx-introspection \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ament-index-cpp \
    rcl-interfaces \
    rclcpp \
    rclcpp-components \
    rcpputils \
    rcutils \
    resource-retriever \
    rosgraph-msgs \
    rosidl-typesupport-introspection-cpp \
    rosx-introspection \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-gtest \
    ament-lint-auto \
    asio \
    nlohmann-json \
    std-msgs \
    std-srvs \
    websocketpp \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/foxglove_bridge-release/archive/release/humble/foxglove_bridge/3.4.2-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/foxglove_bridge"
SRC_URI = "git://github.com/ros2-gbp/foxglove_bridge-release;${ROS_BRANCH};protocol=https"
SRCREV = "82d578797a81bd30711e92e3ca52f0055f72ad0e"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

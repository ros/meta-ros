# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "MOCAP4ROS2 driver for OptiTrack (Motive), with an open NatNet 3.0-4.x implementation and a NatNet simulator"
AUTHOR = "Francisco Martín Rico <fmrico@gmail.com>"
ROS_AUTHOR = "Francisco Martín Rico <fmrico@gmail.com>"
HOMEPAGE = "https://mocap4ros2-project.github.io"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "mocap4ros2_optitrack"
ROS_BPN = "mocap4r2_optitrack_driver"

ROS_BUILD_DEPENDS = "\
    mocap4r2-control \
    mocap4r2-interfaces \
    rclcpp \
    rclcpp-components \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    mocap4r2-control \
    mocap4r2-interfaces \
    rclcpp \
    rclcpp-components \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    launch \
    launch-ros \
    launch-yaml \
    mocap4r2-control \
    mocap4r2-interfaces \
    mocap4r2-marker-viz \
    rclcpp \
    rclcpp-components \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/MOCAP4ROS2-Project/mocap4ros2_optitrack-release/archive/release/humble/mocap4r2_optitrack_driver/2.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/mocap4r2_optitrack_driver"
SRC_URI = "git://github.com/MOCAP4ROS2-Project/mocap4ros2_optitrack-release;${ROS_BRANCH};protocol=https"
SRCREV = "7e14c38d91555edf6f61b922d5da0a278990b0c5"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

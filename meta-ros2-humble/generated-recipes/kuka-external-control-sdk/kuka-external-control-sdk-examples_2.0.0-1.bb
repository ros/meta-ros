# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Examples for using KUKA external control SDK"
AUTHOR = "Gergely Kovacs <kovacsge.work@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "kuka_external_control_sdk"
ROS_BPN = "kuka_external_control_sdk_examples"

ROS_BUILD_DEPENDS = "\
    kuka-external-control-sdk \
"

ROS_BUILDTOOL_DEPENDS = "\
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    kuka-external-control-sdk \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-protobuf-compiler-grpc} \
    grpc \
    libtinyxml2 \
    openssl \
    pkgconfig \
    tinyxml2-vendor \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-cmake \
    kuka-external-control-sdk \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/kuka_external_control_sdk-release/archive/release/humble/kuka_external_control_sdk_examples/2.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/kuka_external_control_sdk_examples"
SRC_URI = "git://github.com/ros2-gbp/kuka_external_control_sdk-release;${ROS_BRANCH};protocol=https"
SRCREV = "87a0e331d848d7c9afaa5cf33e5487314de663f2"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

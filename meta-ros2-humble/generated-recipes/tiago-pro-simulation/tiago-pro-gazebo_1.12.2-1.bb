# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "The tiago_pro_gazebo package"
AUTHOR = "Narcis Miguel <narcis.miguel@pal-robotics.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "tiago_pro_simulation"
ROS_BPN = "tiago_pro_gazebo"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-auto-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    gazebo-plugins \
    gazebo-ros \
    gazebo-ros2-control \
    launch \
    launch-pal \
    launch-ros \
    omni-base-description \
    pal-gazebo-plugins \
    pal-gazebo-worlds \
    pal-maps \
    pal-pro-gripper-description \
    pal-urdf-utils \
    play-motion2-msgs \
    tiago-pro-2dnav \
    tiago-pro-bringup \
    tiago-pro-description \
    tiago-pro-head-description \
    tiago-pro-laser-sensors \
    tiago-pro-moveit-config \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/pal-gbp/tiago_pro_simulation-release/archive/release/humble/tiago_pro_gazebo/1.12.2-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/tiago_pro_gazebo"
SRC_URI = "git://github.com/pal-gbp/tiago_pro_simulation-release;${ROS_BRANCH};protocol=https"
SRCREV = "9f827fd3b71695a872a3e5764a5b61024913dd0a"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

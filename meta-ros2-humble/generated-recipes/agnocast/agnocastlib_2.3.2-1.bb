# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "True Zero Copy Communication Middleware for Unsized ROS 2 Message Types."
AUTHOR = "Takahiro Ishikawa-Aso <sykwer@gmail.com>"
ROS_AUTHOR = "Takahiro Ishikawa-Aso <sykwer@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "agnocast"
ROS_BPN = "agnocastlib"

ROS_BUILD_DEPENDS = " \
    agnocast-cie-config-msgs \
    agnocast-cie-thread-configurator \
    ament-index-cpp \
    glog \
    lttng-ust \
    message-filters \
    rcl-yaml-param-parser \
    rclcpp \
    rclcpp-components \
    rosgraph-msgs \
    tracetools \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    agnocast-cie-config-msgs \
    agnocast-cie-thread-configurator \
    ament-index-cpp \
    glog \
    lttng-ust \
    message-filters \
    rcl-yaml-param-parser \
    rclcpp \
    rclcpp-components \
    rosgraph-msgs \
    tracetools \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    agnocast-cie-config-msgs \
    agnocast-cie-thread-configurator \
    ament-index-cpp \
    glog \
    lttng-ust \
    message-filters \
    rcl-yaml-param-parser \
    rclcpp \
    rclcpp-components \
    rosgraph-msgs \
    tracetools \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-gmock \
    ament-lint-auto \
    ament-lint-common \
    launch-testing-ament-cmake \
    std-msgs \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/agnocast-release/archive/release/humble/agnocastlib/2.3.2-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/agnocastlib"
SRC_URI = "git://github.com/ros2-gbp/agnocast-release;${ROS_BRANCH};protocol=https"
SRCREV = "19ebea246de2bb4a2b63b7bcba745f58c5a4a476"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

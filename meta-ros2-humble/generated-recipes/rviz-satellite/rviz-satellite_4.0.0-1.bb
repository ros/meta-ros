# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Display satellite map tiles in RViz"
AUTHOR = "Andre Schröder <andre.schroeder@tomtom.com>"
ROS_AUTHOR = "Gareth Cross <gcross.code@icloud.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "Apache 2"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=fc216ef9336537897fbeafa564601763"

ROS_CN = "rviz_satellite"
ROS_BPN = "rviz_satellite"

ROS_BUILD_DEPENDS = "\
    angles \
    qtbase \
    rclcpp \
    rcpputils \
    rviz-common \
    rviz-default-plugins \
    sensor-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    angles \
    rclcpp \
    rcpputils \
    rviz-common \
    rviz-default-plugins \
    sensor-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-ignition-cmake2} \
    ${ROS_UNRESOLVED_DEP-ignition-math6} \
    action-msgs \
    ament-cmake \
    ament-cmake-core \
    ament-cmake-export-definitions \
    ament-cmake-export-dependencies \
    ament-cmake-export-include-directories \
    ament-cmake-export-interfaces \
    ament-cmake-export-libraries \
    ament-cmake-export-link-flags \
    ament-cmake-export-targets \
    ament-cmake-gen-version-h \
    ament-cmake-libraries \
    ament-cmake-python \
    ament-cmake-target-dependencies \
    ament-cmake-test \
    ament-cmake-version \
    ament-index-cpp \
    ament-index-python \
    builtin-interfaces \
    class-loader \
    console-bridge \
    console-bridge-vendor \
    curl \
    eigen3-cmake-module \
    freetype \
    geometry-msgs \
    glew \
    ignition-cmake2-vendor \
    ignition-math6-vendor \
    image-transport \
    interactive-markers \
    laser-geometry \
    libcurl-vendor \
    libeigen \
    libstatistics-collector \
    libtinyxml2 \
    libx11 \
    libxaw \
    libxrandr \
    libyaml \
    libyaml-vendor \
    map-msgs \
    mesa \
    message-filters \
    nav-msgs \
    orocos-kdl \
    orocos-kdl-vendor \
    pluginlib \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp-action \
    rclcpp-components \
    rcutils \
    resource-retriever \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-interface \
    rviz-ogre-vendor \
    rviz-rendering \
    statistics-msgs \
    std-msgs \
    tf2 \
    tf2-geometry-msgs \
    tf2-msgs \
    tinyxml2-vendor \
    tracetools \
    unique-identifier-msgs \
    urdf \
    urdf-parser-plugin \
    urdfdom \
    urdfdom-headers \
    visualization-msgs \
    yaml-cpp \
    yaml-cpp-vendor \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-package-native \
    cmake-native \
    eigen3-cmake-module-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-importlib-metadata-native \
    python3-native \
    python3-setuptools-native \
"

ROS_EXEC_DEPENDS = "\
    angles \
    rclcpp \
    rcpputils \
    rviz-common \
    rviz-default-plugins \
    sensor-msgs \
    tf2-ros \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/nobleo/rviz_satellite-release/archive/release/humble/rviz_satellite/4.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/rviz_satellite"
SRC_URI = "git://github.com/nobleo/rviz_satellite-release;${ROS_BRANCH};protocol=https"
SRCREV = "27be29b75833cdf374618513376fdf02bc7d494c"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

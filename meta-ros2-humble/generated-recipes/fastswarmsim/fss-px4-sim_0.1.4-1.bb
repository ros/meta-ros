# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "ROS 2 PX4/MAVROS-compatible drone simulators for FastSwarmSim."
AUTHOR = "Peixuan Shu <shupeixuan@qq.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=4633480cdd27d7906aaf3ef4b72014b2"

ROS_CN = "fastswarmsim"
ROS_BPN = "fss_px4_sim"

ROS_BUILD_DEPENDS = "\
    fss-time \
    geographic-msgs \
    geometry-msgs \
    mavros \
    mavros-msgs \
    nav-msgs \
    rclcpp \
    rclcpp-components \
    sensor-msgs \
    std-msgs \
    tf2 \
    tf2-eigen \
    tf2-geometry-msgs \
    tf2-ros \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    fss-time \
    geographic-msgs \
    geometry-msgs \
    mavros \
    mavros-msgs \
    nav-msgs \
    rclcpp \
    rclcpp-components \
    sensor-msgs \
    std-msgs \
    tf2 \
    tf2-eigen \
    tf2-geometry-msgs \
    tf2-ros \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    fss-time \
    geographic-msgs \
    geometry-msgs \
    launch \
    launch-ros \
    mavros \
    mavros-msgs \
    nav-msgs \
    python3 \
    rclcpp \
    rclcpp-components \
    rclpy \
    robot-state-publisher \
    rviz2 \
    sensor-msgs \
    std-msgs \
    tf2 \
    tf2-eigen \
    tf2-geometry-msgs \
    tf2-ros \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/fastswarmsim-release/archive/release/humble/fss_px4_sim/0.1.4-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/fss_px4_sim"
SRC_URI = "git://github.com/ros2-gbp/fastswarmsim-release;${ROS_BRANCH};protocol=https"
SRCREV = "41c4be13175a0f0a7b4c729deb799a7b6d170608"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "ZeroMQ based conservative lock-step simulation time for FastSwarmSim."
AUTHOR = "Peixuan Shu <shupeixuan@qq.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=4633480cdd27d7906aaf3ef4b72014b2"

ROS_CN = "fastswarmsim"
ROS_BPN = "fss_time"

ROS_BUILD_DEPENDS = "\
    builtin-interfaces \
    fss-time-interfaces \
    pkgconfig \
    rclcpp \
    rosgraph-msgs \
    std-msgs \
    std-srvs \
    zeromq \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    builtin-interfaces \
    fss-time-interfaces \
    rclcpp \
    rosgraph-msgs \
    std-msgs \
    std-srvs \
    zeromq \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    builtin-interfaces \
    fss-time-interfaces \
    launch \
    launch-ros \
    python3-pyqt5 \
    rclcpp \
    rclpy \
    rosgraph-msgs \
    std-msgs \
    std-srvs \
    zeromq \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/fastswarmsim-release/archive/release/humble/fss_time/0.1.4-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/fss_time"
SRC_URI = "git://github.com/ros2-gbp/fastswarmsim-release;${ROS_BRANCH};protocol=https"
SRCREV = "4cc0ce1c28dddd5a61e4563241b7902319d18b8a"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

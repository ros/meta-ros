# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "A KDL-based library implementing an inverse dynamics solver for simulated robots."
AUTHOR = "Enrico Ferrentino <eferrentino@unisa.it>"
ROS_AUTHOR = "Vincenzo Petrone <vipetrone@unisa.it>"
HOMEPAGE = "https://github.com/unisa-acg/inverse-dynamics-solver.git"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "inverse_dynamics_solver"
ROS_BPN = "kdl_inverse_dynamics_solver"

ROS_BUILD_DEPENDS = "\
    inverse-dynamics-solver \
    kdl-parser \
    orocos-kdl \
    pluginlib \
    rclcpp \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    inverse-dynamics-solver \
    kdl-parser \
    pluginlib \
    rclcpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ament-index-cpp \
    builtin-interfaces \
    class-loader \
    eigen3-cmake-module \
    geometry-msgs \
    libeigen \
    libstatistics-collector \
    libtinyxml2 \
    libyaml \
    libyaml-vendor \
    orocos-kdl-vendor \
    rcl \
    rcl-interfaces \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rcpputils \
    rcutils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosbag2-cpp \
    rosbag2-storage \
    rosbag2-storage-default-plugins \
    rosgraph-msgs \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-cpp \
    sensor-msgs \
    shared-queues-vendor \
    sqlite3 \
    sqlite3-vendor \
    statistics-msgs \
    std-msgs \
    tinyxml2-vendor \
    tracetools \
    urdf \
    urdf-parser-plugin \
    urdfdom \
    urdfdom-headers \
    yaml-cpp \
    yaml-cpp-vendor \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-package-native \
    cmake-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-importlib-metadata-native \
    python3-native \
    python3-setuptools-native \
    rosidl-cmake-native \
"

ROS_EXEC_DEPENDS = "\
    inverse-dynamics-solver \
    kdl-parser \
    orocos-kdl \
    pluginlib \
    rclcpp \
    ur-description \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-lint-auto \
    ament-lint-common \
    rclcpp \
    ros-testing \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/inverse_dynamics_solver-release/archive/release/humble/kdl_inverse_dynamics_solver/1.0.4-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/kdl_inverse_dynamics_solver"
SRC_URI = "git://github.com/ros2-gbp/inverse_dynamics_solver-release;${ROS_BRANCH};protocol=https"
SRCREV = "7983623f3488e736158b7b171d6cd0cad27c246c"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

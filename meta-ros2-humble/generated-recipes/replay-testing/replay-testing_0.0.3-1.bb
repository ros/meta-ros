# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "A testing library and CLI for replaying ROS nodes."
AUTHOR = "Troy Gibb <troy@polymathrobotics.com>"
ROS_AUTHOR = "Troy Gibb <troy@polymathrobotics.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "replay_testing"
ROS_BPN = "replay_testing"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    launch \
    python3-boto3 \
    python3-pydantic \
    python3-termcolor \
    rclpy \
    ros2bag \
    rosbag2-py \
    rosbag2-storage-mcap \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-python3-junitparser} \
    ament-cmake-pytest \
    geometry-msgs \
    python3-pytest \
    ros2run \
    ros2topic \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/replay_testing-release/archive/release/humble/replay_testing/0.0.3-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/replay_testing"
SRC_URI = "git://github.com/ros2-gbp/replay_testing-release;${ROS_BRANCH};protocol=https"
SRCREV = "7f615fec86d668e7bdb0cd3ad5d22cd4ea595e5b"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

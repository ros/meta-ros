# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "ROS package to interface with IIO devices"
AUTHOR = "Analog Devices <adrian.suciu@analog.com>"
ROS_AUTHOR = "Adrian Suciu <adrian.suciu@analog.com>"
HOMEPAGE = "https://analogdevicesinc.github.io/iio_ros2/"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License, Version 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=e8978a5103d23266fc6f8ec03dc9eb16"

ROS_CN = "adi_iio"
ROS_BPN = "adi_iio"

ROS_BUILD_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-libiio-dev} \
    rclcpp \
    rosidl-typesupport-introspection-cpp \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
    rosidl-default-generators-native \
"

ROS_EXPORT_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-libiio-dev} \
    rclcpp \
    rosidl-typesupport-introspection-cpp \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-libiio-dev} \
    rclcpp \
    ros2launch \
    rosidl-default-runtime \
    rosidl-typesupport-introspection-cpp \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-cppcheck \
    ament-cmake-cpplint \
    ament-cmake-lint-cmake \
    ament-cmake-ros \
    ament-cmake-xmllint \
    ament-copyright \
    ament-lint-auto \
    ament-lint-common \
    ament-pep257 \
    launch \
    launch-pytest \
    launch-ros \
    launch-testing \
    launch-testing-ament-cmake \
    python3-scipy \
    rclpy \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/adi_iio-release/archive/release/humble/adi_iio/1.0.1-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/adi_iio"
SRC_URI = "git://github.com/ros2-gbp/adi_iio-release;${ROS_BRANCH};protocol=https"
SRCREV = "0e332d610cde0ebe15a117e636430b4ad8854b8d"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

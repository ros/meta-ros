# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Elite Robots CS Series SDK (C++ library for Elibot CS series robotic arms)."
AUTHOR = "Elite Robots <dukang@elibot.cn>"
ROS_AUTHOR = "dukang"
HOMEPAGE = "https://www.eliterobots.com/"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=ba086732c8b3e09d0a15c4bc717c6c44"

ROS_CN = "elite_cs_series_sdk"
ROS_BPN = "elite_cs_series_sdk"

ROS_BUILD_DEPENDS = "\
    boost \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    boost \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    boost \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/EliteRobots/Elite_Robots_CS_SDK-release/archive/release/humble/elite_cs_series_sdk/1.5.0-2.tar.gz
ROS_BRANCH ?= "branch=release/humble/elite_cs_series_sdk"
SRC_URI = "git://github.com/EliteRobots/Elite_Robots_CS_SDK-release;${ROS_BRANCH};protocol=https"
SRCREV = "26cde88e56d43eb5dc912399055ec5e3cf758d6f"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

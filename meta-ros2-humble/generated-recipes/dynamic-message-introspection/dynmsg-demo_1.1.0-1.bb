# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Demo of dynamic message type loading"
AUTHOR = "Geoffrey Biggs <geoff@openrobotics.org>"
ROS_AUTHOR = "Geoffrey Biggs <geoff@openrobotics.org>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "dynamic_message_introspection"
ROS_BPN = "dynmsg_demo"

ROS_BUILD_DEPENDS = "\
    dynmsg \
    rcl \
    rcl-action \
    rmw \
    yaml-cpp-vendor \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    ament-cmake-ros-core-native \
"

ROS_EXPORT_DEPENDS = "\
    dynmsg \
    rcl \
    rcl-action \
    rmw \
    yaml-cpp-vendor \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-ros-core-native \
"

ROS_EXEC_DEPENDS = "\
    dynmsg \
    rcl \
    rcl-action \
    rmw \
    yaml-cpp-vendor \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
    dynmsg-msgs \
    example-interfaces \
    geometry-msgs \
    std-msgs \
    test-msgs \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/dynamic_message_introspection-release/archive/release/humble/dynmsg_demo/1.1.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/dynmsg_demo"
SRC_URI = "git://github.com/ros2-gbp/dynamic_message_introspection-release;${ROS_BRANCH};protocol=https"
SRCREV = "b35928dcbf63719307b92054458a332864a507b0"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

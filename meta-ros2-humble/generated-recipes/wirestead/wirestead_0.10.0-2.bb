# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Cross-platform asynchronous C++ communication library for serial, TCP, UDP, and UDS transports."
AUTHOR = "Jinwoo Sung <jwsung91@gmail.com>"
HOMEPAGE = "https://wirestead.github.io/"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "wirestead"
ROS_BPN = "wirestead"

ROS_BUILD_DEPENDS = "\
    boost \
    spdlog \
"

ROS_BUILDTOOL_DEPENDS = "\
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    boost \
    spdlog \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    spdlog \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/wirestead-release/archive/release/humble/wirestead/0.10.0-2.tar.gz
ROS_BRANCH ?= "branch=release/humble/wirestead"
SRC_URI = "git://github.com/ros2-gbp/wirestead-release;${ROS_BRANCH};protocol=https"
SRCREV = "c47c7f022359b7dfb5506e786fef2d5143217eb0"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

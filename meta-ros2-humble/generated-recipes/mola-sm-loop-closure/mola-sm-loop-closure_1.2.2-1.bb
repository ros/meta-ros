# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Simplemap loop-closure postprocessing library and CLI tool"
AUTHOR = "Jose-Luis Blanco-Claraco <joseluisblancoc@gmail.com>"
ROS_AUTHOR = "Jose-Luis Blanco-Claraco <joseluisblancoc@gmail.com>"
HOMEPAGE = "https://docs.mola-slam.org/"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "GPLv3"
LICENSE = "GPL-3.0-only"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=e9f2deaa804a16d9e0d3965ef77e171e"

ROS_CN = "mola_sm_loop_closure"
ROS_BPN = "mola_sm_loop_closure"

ROS_BUILD_DEPENDS = "\
    gtsam \
    libflann \
    lz4 \
    mola-common \
    mola-georeferencing \
    mola-gtsam-factors \
    mola-pose-list \
    mola-relocalization \
    mola-yaml \
    mp2p-icp \
    mrpt-libgui \
    mrpt-libmaps \
    mrpt-libtclap \
    ros-environment \
    tbb \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-gtest-native \
    ament-cmake-native \
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    gtsam \
    mola-common \
    mola-georeferencing \
    mola-gtsam-factors \
    mola-pose-list \
    mola-relocalization \
    mola-yaml \
    mp2p-icp \
    mrpt-libgui \
    mrpt-libmaps \
    mrpt-libtclap \
    tbb \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    boost \
    cli11 \
    glfw \
    libeigen \
    mola-imu-preintegration \
    mp2p-icp-core \
    mp2p-icp-viz \
    mrpt-libbase \
    mrpt-libmath \
    mrpt-libobs \
    mrpt-libopengl \
    mrpt-libposes \
    mrpt-libslam \
    nanoflann \
    suitesparse-cholmod \
    suitesparse-cxsparse \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-package-native \
    gtest-native \
    gtest-vendor-native \
    python3-catkin-pkg-native \
    python3-importlib-metadata-native \
    python3-native \
    python3-setuptools-native \
"

ROS_EXEC_DEPENDS = "\
    gtsam \
    mola-common \
    mola-georeferencing \
    mola-gtsam-factors \
    mola-pose-list \
    mola-relocalization \
    mola-yaml \
    mp2p-icp \
    mrpt-libgui \
    mrpt-libmaps \
    mrpt-libtclap \
    tbb \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-lint-cmake \
    ament-cmake-pep257 \
    ament-cmake-uncrustify \
    ament-cmake-xmllint \
    ament-lint-auto \
    mola-metric-maps \
    mola-test-datasets \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/mola_sm_loop_closure-release/archive/release/humble/mola_sm_loop_closure/1.2.2-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/mola_sm_loop_closure"
SRC_URI = "git://github.com/ros2-gbp/mola_sm_loop_closure-release;${ROS_BRANCH};protocol=https"
SRCREV = "aefb110ca145135aa31be36a425312f7915ef449"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Standalone C++ library for accessing the Schunk five finger hand."
AUTHOR = "Stefan Scherzinger <scherzin@fzi.de>"
ROS_AUTHOR = "Georg Heppner"
HOMEPAGE = "http://wiki.ros.org/schunk_svh_library"
SECTION = "devel"
LICENSE = "GPL-3.0-or-later"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=5f660bce20dfd88ba2749c28f85619d4"

ROS_CN = "schunk_svh_library"
ROS_BPN = "schunk_svh_library"

ROS_BUILD_DEPENDS = " \
    boost \
"

ROS_BUILDTOOL_DEPENDS = " \
    cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ament-cmake \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    boost \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/schunk_svh_library-release/archive/release/humble/schunk_svh_library/1.0.1-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/schunk_svh_library"
SRC_URI = "git://github.com/ros2-gbp/schunk_svh_library-release;${ROS_BRANCH};protocol=https"
SRCREV = "eb88f49a96664c56f57002f2564ab41a961d28e5"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

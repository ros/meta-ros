# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "The POPF package"
AUTHOR = "Francisco Martin <fmrico@gmail.com>"
ROS_AUTHOR = "Marc Hanheide"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "GPLv2"
LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=2c00b8d2854109dbebef7818b4dae1e2"

ROS_CN = "popf"
ROS_BPN = "popf"

ROS_BUILD_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-coinor-libcbc-dev} \
    ${ROS_UNRESOLVED_DEP-coinor-libcgl-dev} \
    ${ROS_UNRESOLVED_DEP-coinor-libclp-dev} \
    ${ROS_UNRESOLVED_DEP-coinor-libcoinutils-dev} \
    bison \
    flex \
    rclcpp \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-coinor-libcbc-dev} \
    ${ROS_UNRESOLVED_DEP-coinor-libcgl-dev} \
    ${ROS_UNRESOLVED_DEP-coinor-libclp-dev} \
    ${ROS_UNRESOLVED_DEP-coinor-libcoinutils-dev} \
    bison \
    flex \
    rclcpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ament-index-cpp \
    builtin-interfaces \
    libstatistics-collector \
    libyaml \
    libyaml-vendor \
    rcl \
    rcl-interfaces \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rcpputils \
    rcutils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-interface \
    statistics-msgs \
    tracetools \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-package-native \
    cmake-native \
    python3-catkin-pkg-native \
    python3-importlib-metadata-native \
    python3-native \
    python3-setuptools-native \
"

ROS_EXEC_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-coinor-libcbc-dev} \
    ${ROS_UNRESOLVED_DEP-coinor-libcgl-dev} \
    ${ROS_UNRESOLVED_DEP-coinor-libclp-dev} \
    ${ROS_UNRESOLVED_DEP-coinor-libcoinutils-dev} \
    bison \
    flex \
    rclcpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/fmrico/popf-release/archive/release/humble/popf/0.0.14-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/popf"
SRC_URI = "git://github.com/fmrico/popf-release;${ROS_BRANCH};protocol=https"
SRCREV = "17394a4bbdbb21f29f7bfe2ac5d51939fb00ec5e"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "ROS 2 Package for Bitcraze Crazyflie robots"
AUTHOR = "Wolfgang Hönig <hoenig@tu-berlin.de>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "crazyswarm2"
ROS_BPN = "crazyflie"

ROS_BUILD_DEPENDS = " \
    boost \
    crazyflie-interfaces \
    geometry-msgs \
    libeigen \
    libusb1 \
    motion-capture-tracking-interfaces \
    rclcpp \
    ros-environment \
    sensor-msgs \
    std-srvs \
    tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
    ament-cmake-python-native \
"

ROS_EXPORT_DEPENDS = " \
    boost \
    crazyflie-interfaces \
    geometry-msgs \
    libeigen \
    libusb1 \
    motion-capture-tracking-interfaces \
    rclcpp \
    ros-environment \
    sensor-msgs \
    std-srvs \
    tf2-ros \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    boost \
    crazyflie-interfaces \
    geometry-msgs \
    libeigen \
    libusb1 \
    motion-capture-tracking-interfaces \
    rclcpp \
    ros-environment \
    sensor-msgs \
    std-srvs \
    tf-transformations \
    tf2-ros \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/crazyswarm2-release/archive/release/humble/crazyflie/1.0.3-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/crazyflie"
SRC_URI = "git://github.com/ros2-gbp/crazyswarm2-release;${ROS_BRANCH};protocol=https"
SRCREV = "f0557d657c819724e7d1784ad1a101e78be87bf9"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Graph reasoning for extracting semantic concepts using GNNs"
AUTHOR = "adminpc <josmilrom@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "GPLv3"
LICENSE = "GPL-3.0-only"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=1e7b3bcc2e271699c77c769685058cbe"

ROS_CN = "situational_graphs_reasoning"
ROS_BPN = "situational_graphs_reasoning"

ROS_BUILD_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-python3-networkx} \
    ${ROS_UNRESOLVED_DEP-python3-pytorch-pip} \
    ${ROS_UNRESOLVED_DEP-python3-seaborn} \
    ${ROS_UNRESOLVED_DEP-python3-torch-geometric-pip} \
    python3-colorama \
    python3-matplotlib \
    python3-numpy \
    python3-protobuf \
    python3-shapely \
    situational-graphs-datasets \
    situational-graphs-msgs \
    situational-graphs-reasoning-msgs \
    situational-graphs-wrapper \
"

ROS_BUILDTOOL_DEPENDS = ""

ROS_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-python3-networkx} \
    ${ROS_UNRESOLVED_DEP-python3-pytorch-pip} \
    ${ROS_UNRESOLVED_DEP-python3-seaborn} \
    ${ROS_UNRESOLVED_DEP-python3-torch-geometric-pip} \
    python3-colorama \
    python3-matplotlib \
    python3-numpy \
    python3-protobuf \
    python3-shapely \
    situational-graphs-datasets \
    situational-graphs-msgs \
    situational-graphs-reasoning-msgs \
    situational-graphs-wrapper \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    builtin-interfaces \
    fastcdr \
    gcc-runtime \
    geometry-msgs \
    rcpputils \
    rcutils \
    rmw \
    rosidl-cmake \
    rosidl-default-generators \
    rosidl-default-runtime \
    rosidl-generator-py \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-fastrtps-c \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    sensor-msgs \
    std-msgs \
    visualization-msgs \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-gmock-native \
    ament-cmake-gtest-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-native \
    ament-cmake-pytest-native \
    ament-cmake-python-native \
    ament-cmake-ros-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-package-native \
    cmake-native \
    domain-coordinator-native \
    fastcdr-native \
    fastrtps-cmake-module-native \
    gcc-runtime-native \
    gmock-vendor-native \
    gtest-native \
    gtest-vendor-native \
    python-cmake-module-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-importlib-metadata-native \
    python3-native \
    python3-pytest-native \
    python3-setuptools-native \
    rcpputils-native \
    rcutils-native \
    rmw-native \
    ros-environment-native \
    rosidl-cmake-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-py-native \
    rosidl-generator-rs-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-cpp-native \
    rosidl-typesupport-fastrtps-c-native \
    rosidl-typesupport-fastrtps-cpp-native \
    rosidl-typesupport-interface-native \
    rosidl-typesupport-introspection-c-native \
    rosidl-typesupport-introspection-cpp-native \
"

ROS_EXEC_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-python3-networkx} \
    ${ROS_UNRESOLVED_DEP-python3-pytorch-pip} \
    ${ROS_UNRESOLVED_DEP-python3-seaborn} \
    ${ROS_UNRESOLVED_DEP-python3-torch-geometric-pip} \
    python3-colorama \
    python3-matplotlib \
    python3-numpy \
    python3-protobuf \
    python3-shapely \
    situational-graphs-datasets \
    situational-graphs-msgs \
    situational-graphs-reasoning-msgs \
    situational-graphs-wrapper \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-copyright \
    ament-flake8 \
    ament-pep257 \
    python3-pytest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/situational_graphs_reasoning-release/archive/release/humble/situational_graphs_reasoning/0.0.1-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/situational_graphs_reasoning"
SRC_URI = "git://github.com/ros2-gbp/situational_graphs_reasoning-release;${ROS_BRANCH};protocol=https"
SRCREV = "81ff076ca29b0349c6097144f2b1b8a5165f83c6"

ROS_BUILD_TYPE = "ament_python"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "CMake utility toolbox"
AUTHOR = "Guilhem Saurel <guilhem.saurel@laas.fr>"
ROS_AUTHOR = "Justin Carpentier"
HOMEPAGE = "https://github.com/jrl-umi3218/jrl-cmakemodules"
SECTION = "devel"
LICENSE = "GPL-3.0 AND LGPL-3.0 AND BSD-3-Clause AND MIT AND Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=e4c74a520650d71beb18ceaa66a24c70"

ROS_CN = "jrl_cmakemodules"
ROS_BPN = "jrl_cmakemodules"

ROS_BUILD_DEPENDS = "\
    doxygen \
    pkgconfig \
"

ROS_BUILDTOOL_DEPENDS = "\
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    doxygen \
    pkgconfig \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = ""

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    doxygen \
    pkgconfig \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-matio} \
    boost \
    catch2 \
    git \
    libeigen \
    python3-nanobind \
    python3-numpy \
    python3-pytest \
    python3-typing-extensions \
    simde \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/jrl_cmakemodules-release/archive/release/humble/jrl_cmakemodules/2.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/jrl_cmakemodules"
SRC_URI = "git://github.com/ros2-gbp/jrl_cmakemodules-release;${ROS_BRANCH};protocol=https"
SRCREV = "c327d0f9ca5c95c783b5e16977744661a231cdd8"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Robot Raconteur Companion library for C++"
AUTHOR = "John Wason <wason@wasontech.com>"
ROS_AUTHOR = "John Wason <wason@wasontech.com>"
HOMEPAGE = "http://robotraconteur.com"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "Apache 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=3dce4ba60d7e51ec64f3c3dc18672dd3"

ROS_CN = "robotraconteur_companion"
ROS_BPN = "robotraconteur_companion"

ROS_BUILD_DEPENDS = "\
    boost \
    libeigen \
    robotraconteur \
    yaml-cpp \
"

ROS_BUILDTOOL_DEPENDS = "\
    cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = ""

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    boost \
    yaml-cpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    gtest \
    opencv \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/robotraconteur_companion-release/archive/release/humble/robotraconteur_companion/0.4.3-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/robotraconteur_companion"
SRC_URI = "git://github.com/ros2-gbp/robotraconteur_companion-release;${ROS_BRANCH};protocol=https"
SRCREV = "f55216f48af103ebed8cf5ef2f36778ffe7fc02e"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

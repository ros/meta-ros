# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Robot descriptions and moveit configurations for KUKA robots"
AUTHOR = "Aron Svastits <svastits1@gmail.com>"
HOMEPAGE = "https://github.com/kroshu/kuka_robot_descriptions/issues"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "kuka_robot_descriptions"
ROS_BPN = "kuka_robot_descriptions"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    kuka-agilus-support \
    kuka-cybertech-support \
    kuka-fortec-support \
    kuka-iontec-support \
    kuka-kr-moveit-config \
    kuka-lbr-iisy-moveit-config \
    kuka-lbr-iisy-support \
    kuka-lbr-iiwa-moveit-config \
    kuka-lbr-iiwa-support \
    kuka-mock-hardware-interface \
    kuka-quantec-support \
    kuka-resources \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/kuka_robot_descriptions-release/archive/release/humble/kuka_robot_descriptions/0.9.0-2.tar.gz
ROS_BRANCH ?= "branch=release/humble/kuka_robot_descriptions"
SRC_URI = "git://github.com/ros2-gbp/kuka_robot_descriptions-release;${ROS_BRANCH};protocol=https"
SRCREV = "4af412e8499c324a4bac83e7cd17c530d626361a"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Integration tests for the Schunk SVH ROS2 driver"
AUTHOR = "Stefan Scherzinger <scherzin@fzi.de>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "GPL-3.0-or-later"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=5f660bce20dfd88ba2749c28f85619d4"

ROS_CN = "schunk_svh_ros_driver"
ROS_BPN = "schunk_svh_tests"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = ""

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = ""

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    controller-manager-msgs \
    launch \
    launch-ros \
    launch-testing-ament-cmake \
    schunk-svh-driver \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/schunk_svh_ros_driver-release/archive/release/humble/schunk_svh_tests/2.1.1-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/schunk_svh_tests"
SRC_URI = "git://github.com/ros2-gbp/schunk_svh_ros_driver-release;${ROS_BRANCH};protocol=https"
SRCREV = "28817e554b0c1280747b17c0d41037375cafcbe9"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

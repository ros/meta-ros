# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "SLAM package for Raspberry Pi Mouse"
AUTHOR = "RT Corporation <shop@rt-net.jp>"
ROS_AUTHOR = "Shuhei Kozasa <kozasa@rt-net.jp>"
HOMEPAGE = "https://github.com/rt-net/raspimouse_slam_navigation_ros2"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=bb69307f9a8566360ce04a9b7e6a00b7"

ROS_CN = "raspimouse_slam_navigation_ros2"
ROS_BPN = "raspimouse_slam"

ROS_BUILD_DEPENDS = "\
    hls-lfcd-lds-driver \
    joint-state-publisher \
    joy-linux \
    nav2-map-server \
    raspimouse \
    raspimouse-description \
    raspimouse-ros2-examples \
    robot-state-publisher \
    rplidar-ros \
    rviz2 \
    slam-toolbox \
    urg-node \
    xacro \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    hls-lfcd-lds-driver \
    joint-state-publisher \
    joy-linux \
    nav2-map-server \
    raspimouse \
    raspimouse-description \
    raspimouse-ros2-examples \
    robot-state-publisher \
    rplidar-ros \
    rviz2 \
    slam-toolbox \
    urg-node \
    xacro \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-ignition-cmake2} \
    ${ROS_UNRESOLVED_DEP-ignition-gazebo6} \
    ${ROS_UNRESOLVED_DEP-ignition-math6} \
    ${ROS_UNRESOLVED_DEP-ignition-plugin} \
    ${ROS_UNRESOLVED_DEP-libexpected-dev} \
    action-msgs \
    ament-cmake \
    ament-cmake-core \
    ament-cmake-export-definitions \
    ament-cmake-export-dependencies \
    ament-cmake-export-include-directories \
    ament-cmake-export-interfaces \
    ament-cmake-export-libraries \
    ament-cmake-export-link-flags \
    ament-cmake-export-targets \
    ament-cmake-gen-version-h \
    ament-cmake-libraries \
    ament-cmake-python \
    ament-cmake-target-dependencies \
    ament-cmake-test \
    ament-cmake-version \
    ament-index-cpp \
    ament-index-python \
    backward-ros \
    bond \
    bondcpp \
    boost \
    builtin-interfaces \
    camera-calibration-parsers \
    camera-info-manager \
    class-loader \
    composition-interfaces \
    console-bridge \
    console-bridge-vendor \
    control-msgs \
    controller-interface \
    controller-manager \
    controller-manager-msgs \
    curl \
    cv-bridge \
    diagnostic-msgs \
    diagnostic-updater \
    eigen3-cmake-module \
    elfutils \
    ffmpeg \
    fmt \
    freetype \
    generate-parameter-library \
    geometry-msgs \
    glew \
    graphicsmagick \
    gz-ros2-control \
    hardware-interface \
    ign-ros2-control \
    ignition-cmake2-vendor \
    ignition-math6-vendor \
    image-transport \
    image-transport-plugins \
    interactive-markers \
    joint-state-publisher-gui \
    kdl-parser \
    laser-geometry \
    laser-proc \
    launch \
    launch-ros \
    launch-testing \
    launch-testing-ament-cmake \
    libcap \
    libcurl-vendor \
    libeigen \
    libstatistics-collector \
    libtinyxml2 \
    libx11 \
    libxaw \
    libxrandr \
    libyaml \
    libyaml-vendor \
    lifecycle-msgs \
    map-msgs \
    mesa \
    message-filters \
    nav-msgs \
    nav2-common \
    nav2-msgs \
    nav2-util \
    opencv \
    orocos-kdl \
    orocos-kdl-vendor \
    osrf-pycommon \
    parameter-traits \
    pluginlib \
    python3-importlib-metadata \
    python3-numpy \
    python3-pyyaml \
    qtbase \
    raspimouse-msgs \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-lifecycle \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rclcpp-lifecycle \
    rclpy \
    rcpputils \
    rcutils \
    realsense2-camera-msgs \
    realsense2-description \
    realtime-tools \
    resource-retriever \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-default-generators \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-interface \
    rsl \
    rt-usb-9axisimu-driver \
    rviz-common \
    rviz-default-plugins \
    rviz-ogre-vendor \
    rviz-rendering \
    sensor-msgs \
    statistics-msgs \
    std-msgs \
    std-srvs \
    tcb-span \
    tf2 \
    tf2-geometry-msgs \
    tf2-msgs \
    tf2-ros \
    tinyxml2-vendor \
    tl-expected \
    tracetools \
    trajectory-msgs \
    unique-identifier-msgs \
    urdf \
    urdf-parser-plugin \
    urdfdom \
    urdfdom-headers \
    urg-c \
    urg-node-msgs \
    usb-cam \
    v4l-utils \
    visualization-msgs \
    yaml-cpp \
    yaml-cpp-vendor \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-gmock-native \
    ament-cmake-gtest-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-pytest-native \
    ament-cmake-python-native \
    ament-cmake-ros-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-package-native \
    cmake-native \
    domain-coordinator-native \
    eigen3-cmake-module-native \
    fastcdr-native \
    fastrtps-cmake-module-native \
    generate-parameter-library-py-native \
    gmock-vendor-native \
    gtest-native \
    gtest-vendor-native \
    launch-testing-native \
    pkgconfig-native \
    python-cmake-module-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-importlib-metadata-native \
    python3-jinja2-native \
    python3-native \
    python3-pytest-native \
    python3-pyyaml-native \
    python3-setuptools-native \
    python3-typeguard-native \
    rcpputils-native \
    rcutils-native \
    rmw-native \
    ros-environment-native \
    rosidl-cmake-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-py-native \
    rosidl-generator-rs-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-cpp-native \
    rosidl-typesupport-fastrtps-c-native \
    rosidl-typesupport-fastrtps-cpp-native \
    rosidl-typesupport-interface-native \
    rosidl-typesupport-introspection-c-native \
    rosidl-typesupport-introspection-cpp-native \
"

ROS_EXEC_DEPENDS = "\
    hls-lfcd-lds-driver \
    joint-state-publisher \
    joy-linux \
    nav2-map-server \
    raspimouse \
    raspimouse-description \
    raspimouse-ros2-examples \
    robot-state-publisher \
    rplidar-ros \
    rviz2 \
    slam-toolbox \
    urg-node \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/raspimouse_slam_navigation_ros2-release/archive/release/humble/raspimouse_slam/2.1.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/raspimouse_slam"
SRC_URI = "git://github.com/ros2-gbp/raspimouse_slam_navigation_ros2-release;${ROS_BRANCH};protocol=https"
SRCREV = "b745809710e8cc86dd3f3aa56a3d4dfbd966884b"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Navigation package for Raspberry Pi Mouse"
AUTHOR = "RT Corporation <shop@rt-net.jp>"
ROS_AUTHOR = "Shuhei Kozasa <kozasa@rt-net.jp>"
HOMEPAGE = "https://github.com/rt-net/raspimouse_slam_navigation_ros2"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=bb69307f9a8566360ce04a9b7e6a00b7"

ROS_CN = "raspimouse_slam_navigation_ros2"
ROS_BPN = "raspimouse_navigation"

ROS_BUILD_DEPENDS = " \
    hls-lfcd-lds-driver \
    nav2-bringup \
    raspimouse \
    raspimouse-slam \
    rplidar-ros \
    rviz2 \
    urg-node \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    hls-lfcd-lds-driver \
    nav2-bringup \
    raspimouse \
    raspimouse-slam \
    rplidar-ros \
    rviz2 \
    urg-node \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    hls-lfcd-lds-driver \
    nav2-bringup \
    raspimouse \
    raspimouse-slam \
    rplidar-ros \
    rviz2 \
    urg-node \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/raspimouse_slam_navigation_ros2-release/archive/release/humble/raspimouse_navigation/2.1.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/raspimouse_navigation"
SRC_URI = "git://github.com/ros2-gbp/raspimouse_slam_navigation_ros2-release;${ROS_BRANCH};protocol=https"
SRCREV = "380c2be291c396b2d49add0f62076e8f0e81f08f"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

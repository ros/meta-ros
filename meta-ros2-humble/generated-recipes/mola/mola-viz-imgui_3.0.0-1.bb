# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Dear ImGui (docking branch) GUI backend for MOLA"
AUTHOR = "Jose-Luis Blanco-Claraco <joseluisblancoc@gmail.com>"
HOMEPAGE = "https://github.com/MOLAorg/mola/tree/develop/mola_viz_imgui"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "GPLv3"
LICENSE = "GPL-3.0-only"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=e9f2deaa804a16d9e0d3965ef77e171e"

ROS_CN = "mola"
ROS_BPN = "mola_viz_imgui"

ROS_BUILD_DEPENDS = "\
    freeglut \
    glfw \
    mesa \
    mola-kernel \
    mrpt-libgui \
    mrpt-libmaps \
    mrpt-libobs \
    mrpt-libopengl \
"

ROS_BUILDTOOL_DEPENDS = "\
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    freeglut \
    glfw \
    mesa \
    mola-kernel \
    mrpt-libgui \
    mrpt-libmaps \
    mrpt-libobs \
    mrpt-libopengl \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    libeigen \
    mola-common \
    mola-yaml \
    mrpt-libbase \
    mrpt-libmath \
    mrpt-libposes \
    nanoflann \
    suitesparse-cholmod \
    suitesparse-cxsparse \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    freeglut \
    glfw \
    mesa \
    mola-kernel \
    mrpt-libgui \
    mrpt-libmaps \
    mrpt-libobs \
    mrpt-libopengl \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/mola-release/archive/release/humble/mola_viz_imgui/3.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/mola_viz_imgui"
SRC_URI = "git://github.com/ros2-gbp/mola-release;${ROS_BRANCH};protocol=https"
SRCREV = "611c32ad7fbae4e4e7a9506f222f54031b534e97"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "The autoware_trajectory package"
AUTHOR = "Yukinari Hisaki <yukinari.hisaki.2@tier4.jp>"
ROS_AUTHOR = "Yukinari Hisaki <yukinari.hisaki.2@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_core"
ROS_BPN = "autoware_trajectory"

ROS_BUILD_DEPENDS = " \
    autoware-internal-planning-msgs \
    autoware-lanelet2-utils \
    autoware-planning-msgs \
    autoware-utils-geometry \
    fmt \
    geometry-msgs \
    lanelet2-core \
    rclcpp \
    tf2 \
    tf2-geometry-msgs \
    tl-expected \
    yaml-cpp \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-auto-native \
    autoware-cmake-native \
    python-cmake-module-native \
"

ROS_EXPORT_DEPENDS = " \
    autoware-internal-planning-msgs \
    autoware-lanelet2-utils \
    autoware-planning-msgs \
    autoware-utils-geometry \
    fmt \
    geometry-msgs \
    lanelet2-core \
    rclcpp \
    tf2 \
    tf2-geometry-msgs \
    tl-expected \
    yaml-cpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    autoware-internal-planning-msgs \
    autoware-lanelet2-utils \
    autoware-planning-msgs \
    autoware-utils-geometry \
    fmt \
    geometry-msgs \
    lanelet2-core \
    rclcpp \
    tf2 \
    tf2-geometry-msgs \
    tl-expected \
    yaml-cpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-auto \
    ament-index-cpp \
    autoware-lint-common \
    autoware-motion-utils \
    autoware-pyplot \
    autoware-test-utils \
    autoware-utils-geometry \
    pybind11-vendor \
    python3 \
    python3-matplotlib \
    range-v3 \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/autoware_core-release/archive/release/humble/autoware_trajectory/1.7.0-2.tar.gz
ROS_BRANCH ?= "branch=release/humble/autoware_trajectory"
SRC_URI = "git://github.com/ros2-gbp/autoware_core-release;${ROS_BRANCH};protocol=https"
SRCREV = "b55e3c34ac95b35b8d5e10a081aa5641978a9e5c"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

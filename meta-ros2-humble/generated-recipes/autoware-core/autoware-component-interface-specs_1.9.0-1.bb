# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "The autoware_component_interface_specs package"
AUTHOR = "Takagi, Isamu <isamu.takagi@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_core"
ROS_BPN = "autoware_component_interface_specs"

ROS_BUILD_DEPENDS = "\
    autoware-adapi-v1-msgs \
    autoware-control-msgs \
    autoware-localization-msgs \
    autoware-map-msgs \
    autoware-perception-msgs \
    autoware-planning-msgs \
    autoware-system-msgs \
    autoware-vehicle-msgs \
    nav-msgs \
    rcl \
    rclcpp \
    rosidl-runtime-cpp \
    sensor-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native \
    autoware-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    autoware-adapi-v1-msgs \
    autoware-control-msgs \
    autoware-localization-msgs \
    autoware-map-msgs \
    autoware-perception-msgs \
    autoware-planning-msgs \
    autoware-system-msgs \
    autoware-vehicle-msgs \
    nav-msgs \
    rcl \
    rclcpp \
    rosidl-runtime-cpp \
    sensor-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ament-index-cpp \
    autoware-common-msgs \
    builtin-interfaces \
    diagnostic-msgs \
    geographic-msgs \
    geometry-msgs \
    libstatistics-collector \
    libyaml \
    libyaml-vendor \
    rcl-interfaces \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rcpputils \
    rcutils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-runtime-c \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-interface \
    shape-msgs \
    statistics-msgs \
    std-msgs \
    tracetools \
    unique-identifier-msgs \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-gmock-native \
    ament-cmake-gtest-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-lint-auto-native \
    ament-package-native \
    cmake-native \
    gmock-vendor-native \
    gtest-native \
    gtest-vendor-native \
    python3-catkin-pkg-native \
    python3-importlib-metadata-native \
    python3-native \
    python3-setuptools-native \
    ros-environment-native \
"

ROS_EXEC_DEPENDS = "\
    autoware-adapi-v1-msgs \
    autoware-control-msgs \
    autoware-localization-msgs \
    autoware-map-msgs \
    autoware-perception-msgs \
    autoware-planning-msgs \
    autoware-system-msgs \
    autoware-vehicle-msgs \
    nav-msgs \
    rcl \
    rclcpp \
    rosidl-runtime-cpp \
    sensor-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-lint-auto \
    autoware-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/autoware_core-release/archive/release/humble/autoware_component_interface_specs/1.9.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/autoware_component_interface_specs"
SRC_URI = "git://github.com/ros2-gbp/autoware_core-release;${ROS_BRANCH};protocol=https"
SRCREV = "8fb3306694bbb232d16496c1ab53a50de26cfcb6"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "The autoware_component_interface_specs package"
AUTHOR = "Takagi, Isamu <isamu.takagi@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_core"
ROS_BPN = "autoware_component_interface_specs"

ROS_BUILD_DEPENDS = " \
    autoware-adapi-v1-msgs \
    autoware-control-msgs \
    autoware-localization-msgs \
    autoware-map-msgs \
    autoware-perception-msgs \
    autoware-planning-msgs \
    autoware-system-msgs \
    autoware-vehicle-msgs \
    nav-msgs \
    rcl \
    rclcpp \
    rosidl-runtime-cpp \
    sensor-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-auto-native \
    autoware-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    autoware-adapi-v1-msgs \
    autoware-control-msgs \
    autoware-localization-msgs \
    autoware-map-msgs \
    autoware-perception-msgs \
    autoware-planning-msgs \
    autoware-system-msgs \
    autoware-vehicle-msgs \
    nav-msgs \
    rcl \
    rclcpp \
    rosidl-runtime-cpp \
    sensor-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    autoware-adapi-v1-msgs \
    autoware-control-msgs \
    autoware-localization-msgs \
    autoware-map-msgs \
    autoware-perception-msgs \
    autoware-planning-msgs \
    autoware-system-msgs \
    autoware-vehicle-msgs \
    nav-msgs \
    rcl \
    rclcpp \
    rosidl-runtime-cpp \
    sensor-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-gtest \
    ament-lint-auto \
    autoware-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/autoware_core-release/archive/release/humble/autoware_component_interface_specs/1.4.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/autoware_component_interface_specs"
SRC_URI = "git://github.com/ros2-gbp/autoware_core-release;${ROS_BRANCH};protocol=https"
SRCREV = "7c0dbecdbc2d53b5449a0461ac3e8e6dbf1d6214"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

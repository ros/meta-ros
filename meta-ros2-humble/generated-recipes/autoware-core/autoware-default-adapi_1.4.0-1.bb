# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "The autoware_default_adapi package"
AUTHOR = "Takagi, Isamu <isamu.takagi@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_core"
ROS_BPN = "autoware_default_adapi"

ROS_BUILD_DEPENDS = " \
    autoware-adapi-specs \
    autoware-adapi-v1-msgs \
    autoware-adapi-version-msgs \
    autoware-component-interface-specs \
    autoware-geography-utils \
    autoware-localization-msgs \
    autoware-motion-utils \
    autoware-planning-msgs \
    autoware-system-msgs \
    autoware-utils-rclcpp \
    autoware-vehicle-info-utils \
    autoware-vehicle-msgs \
    diagnostic-updater \
    geographic-msgs \
    nav-msgs \
    rclcpp \
    rclcpp-components \
    shape-msgs \
    std-srvs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-auto-native \
    autoware-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    autoware-adapi-specs \
    autoware-adapi-v1-msgs \
    autoware-adapi-version-msgs \
    autoware-component-interface-specs \
    autoware-geography-utils \
    autoware-localization-msgs \
    autoware-motion-utils \
    autoware-planning-msgs \
    autoware-system-msgs \
    autoware-utils-rclcpp \
    autoware-vehicle-info-utils \
    autoware-vehicle-msgs \
    diagnostic-updater \
    geographic-msgs \
    nav-msgs \
    rclcpp \
    rclcpp-components \
    shape-msgs \
    std-srvs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    autoware-adapi-specs \
    autoware-adapi-v1-msgs \
    autoware-adapi-version-msgs \
    autoware-component-interface-specs \
    autoware-geography-utils \
    autoware-global-parameter-loader \
    autoware-localization-msgs \
    autoware-motion-utils \
    autoware-planning-msgs \
    autoware-system-msgs \
    autoware-utils-rclcpp \
    autoware-vehicle-info-utils \
    autoware-vehicle-msgs \
    diagnostic-updater \
    geographic-msgs \
    nav-msgs \
    python3-flask \
    rclcpp \
    rclcpp-components \
    shape-msgs \
    std-srvs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-lint-auto \
    autoware-lint-common \
    launch-testing \
    launch-testing-ament-cmake \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/autoware_core-release/archive/release/humble/autoware_default_adapi/1.4.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/autoware_default_adapi"
SRC_URI = "git://github.com/ros2-gbp/autoware_core-release;${ROS_BRANCH};protocol=https"
SRCREV = "38614c7d336a2444e7eac805680f4418049b4030"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

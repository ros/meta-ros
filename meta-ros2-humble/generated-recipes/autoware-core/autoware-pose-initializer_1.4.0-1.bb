# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "The autoware_pose_initializer package"
AUTHOR = "Yamato Ando <yamato.ando@tier4.jp>"
ROS_AUTHOR = "Yamato Ando <yamato.ando@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=15;endline=15;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_core"
ROS_BPN = "autoware_pose_initializer"

ROS_BUILD_DEPENDS = " \
    autoware-adapi-v1-msgs \
    autoware-component-interface-specs \
    autoware-map-height-fitter \
    autoware-motion-utils \
    autoware-utils-diagnostics \
    autoware-utils-logging \
    geometry-msgs \
    rclcpp \
    rclcpp-components \
    std-srvs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
    autoware-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    autoware-adapi-v1-msgs \
    autoware-component-interface-specs \
    autoware-map-height-fitter \
    autoware-motion-utils \
    autoware-utils-diagnostics \
    autoware-utils-logging \
    geometry-msgs \
    rclcpp \
    rclcpp-components \
    std-srvs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    autoware-adapi-v1-msgs \
    autoware-component-interface-specs \
    autoware-map-height-fitter \
    autoware-motion-utils \
    autoware-utils-diagnostics \
    autoware-utils-logging \
    geometry-msgs \
    rclcpp \
    rclcpp-components \
    std-srvs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-cppcheck \
    ament-cmake-gmock \
    ament-lint-auto \
    autoware-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/autoware_core-release/archive/release/humble/autoware_pose_initializer/1.4.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/autoware_pose_initializer"
SRC_URI = "git://github.com/ros2-gbp/autoware_core-release;${ROS_BRANCH};protocol=https"
SRCREV = "4a4e9740a76c94a1e6437835ac36b6a3127351c0"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

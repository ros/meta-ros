# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "The ROS 2 autoware_ground_filter package"
AUTHOR = "amc-nu <abrahammonrroy@yahoo.com>"
ROS_AUTHOR = "Open Perception"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_core"
ROS_BPN = "autoware_ground_filter"

ROS_BUILD_DEPENDS = "\
    ament-index-cpp \
    autoware-point-types \
    autoware-utils-debug \
    autoware-utils-geometry \
    autoware-utils-math \
    autoware-utils-system \
    autoware-utils-tf \
    autoware-vehicle-info-utils \
    message-filters \
    pcl-conversions \
    pcl-ros \
    rclcpp \
    rclcpp-components \
    sensor-msgs \
    std-msgs \
    tf2 \
    tf2-eigen \
    tf2-ros \
    tf2-sensor-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native \
    autoware-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    ament-index-cpp \
    autoware-point-types \
    autoware-utils-debug \
    autoware-utils-geometry \
    autoware-utils-math \
    autoware-utils-system \
    autoware-utils-tf \
    autoware-vehicle-info-utils \
    message-filters \
    pcl-conversions \
    pcl-ros \
    rclcpp \
    rclcpp-components \
    sensor-msgs \
    std-msgs \
    tf2 \
    tf2-eigen \
    tf2-ros \
    tf2-sensor-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    action-msgs \
    ament-cmake \
    ament-cmake-copyright \
    ament-cmake-core \
    ament-cmake-cppcheck \
    ament-cmake-export-definitions \
    ament-cmake-export-dependencies \
    ament-cmake-export-include-directories \
    ament-cmake-export-interfaces \
    ament-cmake-export-libraries \
    ament-cmake-export-link-flags \
    ament-cmake-export-targets \
    ament-cmake-gen-version-h \
    ament-cmake-libraries \
    ament-cmake-lint-cmake \
    ament-cmake-python \
    ament-cmake-target-dependencies \
    ament-cmake-test \
    ament-cmake-version \
    ament-cmake-xmllint \
    autoware-common-msgs \
    autoware-internal-debug-msgs \
    autoware-internal-localization-msgs \
    autoware-internal-metric-msgs \
    autoware-internal-msgs \
    autoware-internal-perception-msgs \
    autoware-internal-planning-msgs \
    autoware-perception-msgs \
    autoware-planning-msgs \
    autoware-utils-rclcpp \
    autoware-vehicle-msgs \
    boost \
    builtin-interfaces \
    console-bridge \
    console-bridge-vendor \
    diagnostic-msgs \
    eigen3-cmake-module \
    fmt \
    gcc-runtime \
    geometry-msgs \
    libeigen \
    libstatistics-collector \
    libyaml \
    libyaml-vendor \
    nav-msgs \
    orocos-kdl \
    orocos-kdl-vendor \
    pcl \
    pcl-msgs \
    point-cloud-msg-wrapper \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp-action \
    rcpputils \
    rcutils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-interface \
    statistics-msgs \
    tf2-geometry-msgs \
    tf2-msgs \
    tracetools \
    unique-identifier-msgs \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-gmock-native \
    ament-cmake-gtest-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-copyright-native \
    ament-cppcheck-native \
    ament-lint-auto-native \
    ament-lint-cmake-native \
    ament-package-native \
    ament-xmllint-native \
    cmake-native \
    eigen3-cmake-module-native \
    gmock-vendor-native \
    gtest-native \
    gtest-vendor-native \
    python3-catkin-pkg-native \
    python3-importlib-metadata-native \
    python3-native \
    python3-setuptools-native \
    ros-environment-native \
"

ROS_EXEC_DEPENDS = "\
    ament-index-cpp \
    autoware-point-types \
    autoware-utils-debug \
    autoware-utils-geometry \
    autoware-utils-math \
    autoware-utils-system \
    autoware-utils-tf \
    autoware-vehicle-info-utils \
    message-filters \
    pcl-conversions \
    pcl-ros \
    rclcpp \
    rclcpp-components \
    sensor-msgs \
    std-msgs \
    tf2 \
    tf2-eigen \
    tf2-ros \
    tf2-sensor-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-ros \
    ament-lint-auto \
    autoware-lint-common \
    autoware-test-utils \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/autoware_core-release/archive/release/humble/autoware_ground_filter/1.9.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/autoware_ground_filter"
SRC_URI = "git://github.com/ros2-gbp/autoware_core-release;${ROS_BRANCH};protocol=https"
SRCREV = "df2144f220960ac277a67b58e29b268124ae4715"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "ROS 2 node for testing interface of the nodes in planning module"
AUTHOR = "Kyoichi Sugahara <kyoichi.sugahara@tier4.jp>"
ROS_AUTHOR = "Kyoichi Sugahara <kyoichi.sugahara@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_core"
ROS_BPN = "autoware_planning_test_manager"

ROS_BUILD_DEPENDS = "\
    autoware-component-interface-specs \
    autoware-motion-utils \
    autoware-planning-msgs \
    autoware-route-handler \
    autoware-test-utils \
    autoware-utils-geometry \
    nav-msgs \
    rclcpp \
    tf2-msgs \
    tf2-ros \
    unique-identifier-msgs \
    yaml-cpp-vendor \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native \
    autoware-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    autoware-component-interface-specs \
    autoware-motion-utils \
    autoware-planning-msgs \
    autoware-route-handler \
    autoware-test-utils \
    autoware-utils-geometry \
    nav-msgs \
    rclcpp \
    tf2-msgs \
    tf2-ros \
    unique-identifier-msgs \
    yaml-cpp-vendor \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    action-msgs \
    ament-cmake \
    ament-cmake-core \
    ament-cmake-export-definitions \
    ament-cmake-export-dependencies \
    ament-cmake-export-include-directories \
    ament-cmake-export-interfaces \
    ament-cmake-export-libraries \
    ament-cmake-export-link-flags \
    ament-cmake-export-targets \
    ament-cmake-gen-version-h \
    ament-cmake-libraries \
    ament-cmake-python \
    ament-cmake-target-dependencies \
    ament-cmake-test \
    ament-cmake-version \
    ament-index-cpp \
    autoware-adapi-v1-msgs \
    autoware-common-msgs \
    autoware-control-msgs \
    autoware-internal-planning-msgs \
    autoware-interpolation \
    autoware-lanelet2-extension \
    autoware-lanelet2-utils \
    autoware-localization-msgs \
    autoware-map-msgs \
    autoware-perception-msgs \
    autoware-system-msgs \
    autoware-trajectory \
    autoware-utils-math \
    autoware-utils-system \
    autoware-utils-visualization \
    autoware-vehicle-msgs \
    boost \
    builtin-interfaces \
    console-bridge \
    console-bridge-vendor \
    diagnostic-msgs \
    eigen3-cmake-module \
    fmt \
    geographic-msgs \
    geographiclib \
    geometry-msgs \
    lanelet2-core \
    lanelet2-io \
    lanelet2-maps \
    lanelet2-projection \
    lanelet2-routing \
    lanelet2-traffic-rules \
    lanelet2-validation \
    libeigen \
    libstatistics-collector \
    libyaml \
    libyaml-vendor \
    message-filters \
    orocos-kdl \
    orocos-kdl-vendor \
    pugixml \
    range-v3 \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp-action \
    rclcpp-components \
    rcpputils \
    rcutils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-interface \
    sensor-msgs \
    shape-msgs \
    statistics-msgs \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-eigen \
    tf2-geometry-msgs \
    tl-expected \
    tracetools \
    visualization-msgs \
    yaml-cpp \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-gmock-native \
    ament-cmake-gtest-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-lint-auto-native \
    ament-package-native \
    cmake-native \
    gmock-vendor-native \
    gtest-native \
    gtest-vendor-native \
    lcov-native \
    mrt-cmake-modules-native \
    python3-catkin-pkg-native \
    python3-importlib-metadata-native \
    python3-native \
    python3-pyyaml-native \
    python3-rospkg-native \
    python3-setuptools-native \
    ros-environment-native \
"

ROS_EXEC_DEPENDS = "\
    autoware-component-interface-specs \
    autoware-motion-utils \
    autoware-planning-msgs \
    autoware-route-handler \
    autoware-test-utils \
    autoware-utils-geometry \
    nav-msgs \
    rclcpp \
    tf2-msgs \
    tf2-ros \
    unique-identifier-msgs \
    yaml-cpp-vendor \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-ros \
    ament-lint-auto \
    autoware-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/autoware_core-release/archive/release/humble/autoware_planning_test_manager/1.9.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/autoware_planning_test_manager"
SRC_URI = "git://github.com/ros2-gbp/autoware_core-release;${ROS_BRANCH};protocol=https"
SRCREV = "b3c159e115e8dbdd9e7afaf0bb6d3189dfe2f217"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

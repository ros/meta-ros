# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Nebula Velodyne ROS Wrapper"
AUTHOR = "David Wong <david.wong@tier4.jp>"
ROS_AUTHOR = "TIER IV"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache 2"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=fc216ef9336537897fbeafa564601763"

ROS_CN = "nebula"
ROS_BPN = "nebula_velodyne"

ROS_BUILD_DEPENDS = "\
    boost \
    diagnostic-msgs \
    diagnostic-updater \
    nebula-core-common \
    nebula-core-decoders \
    nebula-core-hw-interfaces \
    nebula-core-ros \
    nebula-msgs \
    nebula-velodyne-common \
    nebula-velodyne-decoders \
    nebula-velodyne-hw-interfaces \
    rclcpp \
    rclcpp-components \
    velodyne-msgs \
    yaml-cpp \
"

ROS_BUILDTOOL_DEPENDS = "\
    autoware-cmake-native \
    ros-environment-native \
    ros-testing-native \
"

ROS_EXPORT_DEPENDS = "\
    boost \
    diagnostic-msgs \
    diagnostic-updater \
    nebula-core-common \
    nebula-core-decoders \
    nebula-core-hw-interfaces \
    nebula-core-ros \
    nebula-msgs \
    nebula-velodyne-common \
    nebula-velodyne-decoders \
    nebula-velodyne-hw-interfaces \
    rclcpp \
    rclcpp-components \
    velodyne-msgs \
    yaml-cpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libpng++-dev} \
    action-msgs \
    ament-index-cpp \
    angles \
    builtin-interfaces \
    class-loader \
    gcc-runtime \
    geometry-msgs \
    libeigen \
    libpng \
    libstatistics-collector \
    libtinyxml2 \
    libyaml \
    libyaml-vendor \
    nlohmann-json \
    pluginlib \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-lifecycle \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclpy \
    rcpputils \
    rcutils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosbag2-storage \
    rosgraph-msgs \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-interface \
    sensor-msgs \
    statistics-msgs \
    std-msgs \
    tinyxml2-vendor \
    tracetools \
    unique-identifier-msgs \
    yaml-cpp-vendor \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    action-msgs-native \
    ament-cmake-auto-native \
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-gmock-native \
    ament-cmake-gtest-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-cpp-native \
    ament-index-python-native \
    ament-lint-auto-native \
    ament-package-native \
    builtin-interfaces-native \
    cmake-native \
    composition-interfaces-native \
    gcc-runtime-native \
    gmock-vendor-native \
    gtest-native \
    gtest-vendor-native \
    launch-native \
    launch-ros-native \
    launch-testing-ament-cmake-native \
    launch-testing-native \
    launch-testing-ros-native \
    libyaml-native \
    libyaml-vendor-native \
    lifecycle-msgs-native \
    osrf-pycommon-native \
    python-cmake-module-native \
    python3-catkin-pkg-native \
    python3-importlib-metadata-native \
    python3-native \
    python3-pyyaml-native \
    python3-setuptools-native \
    rcl-action-native \
    rcl-interfaces-native \
    rcl-lifecycle-native \
    rcl-logging-interface-native \
    rcl-logging-spdlog-native \
    rcl-native \
    rcl-yaml-param-parser-native \
    rclpy-native \
    rcpputils-native \
    rcutils-native \
    rmw-implementation-cmake-native \
    rmw-implementation-native \
    rmw-native \
    ros2cli-native \
    ros2test-native \
    rosidl-runtime-c-native \
    rosidl-typesupport-interface-native \
    tracetools-native \
    unique-identifier-msgs-native \
"

ROS_EXEC_DEPENDS = "\
    boost \
    diagnostic-msgs \
    diagnostic-updater \
    nebula-core-common \
    nebula-core-decoders \
    nebula-core-hw-interfaces \
    nebula-core-ros \
    nebula-msgs \
    nebula-velodyne-common \
    nebula-velodyne-decoders \
    nebula-velodyne-hw-interfaces \
    rclcpp \
    rclcpp-components \
    velodyne-msgs \
    yaml-cpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-lint-auto \
    ros-testing \
    rosbag2-cpp \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/nebula-release/archive/release/humble/nebula_velodyne/1.2.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/nebula_velodyne"
SRC_URI = "git://github.com/ros2-gbp/nebula-release;${ROS_BRANCH};protocol=https"
SRCREV = "d358c74a3e226a6dfb49fb0f6a5625370216f1a4"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "HTTP gateway for ros2_medkit diagnostics system"
AUTHOR = "bburda <bartoszburda93@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "ros2_medkit"
ROS_BPN = "ros2_medkit_gateway"

ROS_BUILD_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libcpp-httplib-dev} \
    action-msgs \
    ament-index-cpp \
    lifecycle-msgs \
    nlohmann-json \
    openssl \
    rcl-interfaces \
    rclcpp \
    ros2-medkit-msgs \
    ros2-medkit-serialization \
    rosidl-typesupport-cpp \
    rosidl-typesupport-introspection-cpp \
    sensor-msgs \
    sqlite3 \
    std-msgs \
    std-srvs \
    yaml-cpp-vendor \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    ros2-medkit-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libcpp-httplib-dev} \
    action-msgs \
    ament-index-cpp \
    lifecycle-msgs \
    nlohmann-json \
    openssl \
    rcl-interfaces \
    rclcpp \
    ros2-medkit-msgs \
    ros2-medkit-serialization \
    rosidl-typesupport-cpp \
    rosidl-typesupport-introspection-cpp \
    sensor-msgs \
    sqlite3 \
    std-msgs \
    std-srvs \
    yaml-cpp-vendor \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    builtin-interfaces \
    diagnostic-msgs \
    gcc-runtime \
    geometry-msgs \
    libstatistics-collector \
    libyaml \
    libyaml-vendor \
    rcl \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rcpputils \
    rcutils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-interface \
    rosidl-typesupport-introspection-c \
    statistics-msgs \
    tracetools \
    unique-identifier-msgs \
    yaml-cpp \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-package-native \
    cmake-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-importlib-metadata-native \
    python3-native \
    python3-setuptools-native \
    rosidl-cmake-native \
"

ROS_EXEC_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libcpp-httplib-dev} \
    action-msgs \
    ament-index-cpp \
    ament-index-python \
    launch \
    launch-ros \
    lifecycle-msgs \
    nlohmann-json \
    openssl \
    rcl-interfaces \
    rclcpp \
    ros2-medkit-action-status-bridge \
    ros2-medkit-diagnostic-bridge \
    ros2-medkit-fault-manager \
    ros2-medkit-log-bridge \
    ros2-medkit-msgs \
    ros2-medkit-serialization \
    rosidl-parser \
    rosidl-runtime-py \
    rosidl-typesupport-cpp \
    rosidl-typesupport-introspection-cpp \
    sensor-msgs \
    sqlite3 \
    std-msgs \
    std-srvs \
    yaml-cpp-vendor \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-clang-format \
    ament-cmake-clang-tidy \
    ament-cmake-gtest \
    ament-lint-auto \
    ament-lint-common \
    example-interfaces \
    rclcpp-action \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/ros2_medkit-release/archive/release/humble/ros2_medkit_gateway/0.6.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/ros2_medkit_gateway"
SRC_URI = "git://github.com/ros2-gbp/ros2_medkit-release;${ROS_BRANCH};protocol=https"
SRCREV = "220edd181b6fc2e14b800f765e74bdae7e1ff9e5"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

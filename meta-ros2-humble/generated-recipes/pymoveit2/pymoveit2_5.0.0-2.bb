# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Basic Python interface for MoveIt 2 built on top of ROS 2 actions and services"
AUTHOR = "Andrej Orsula <orsula.andrej@gmail.com>"
ROS_AUTHOR = "Andrej Orsula"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=4633480cdd27d7906aaf3ef4b72014b2"

ROS_CN = "pymoveit2"
ROS_BPN = "pymoveit2"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    ament-cmake-python-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    action-msgs \
    control-msgs \
    geometry-msgs \
    moveit-msgs \
    python3-numpy \
    rcl-interfaces \
    rclpy \
    sensor-msgs \
    shape-msgs \
    std-msgs \
    std-srvs \
    trajectory-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-pytest \
    python3-pytest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/pymoveit2-release/archive/release/humble/pymoveit2/5.0.0-2.tar.gz
ROS_BRANCH ?= "branch=release/humble/pymoveit2"
SRC_URI = "git://github.com/ros2-gbp/pymoveit2-release;${ROS_BRANCH};protocol=https"
SRCREV = "a746c7bddc11bd14eb60da14cbe7dc65a4b1ff66"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

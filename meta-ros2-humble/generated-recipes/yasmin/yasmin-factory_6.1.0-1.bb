# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "YASMIN factory to create FSMs from XML files"
AUTHOR = "Miguel Ángel González Santamarta <mgons@unileon.es>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "yasmin"
ROS_BPN = "yasmin_factory"

ROS_BUILD_DEPENDS = "\
    ament-index-cpp \
    class-loader \
    pluginlib \
    python3 \
    python3-pybind11 \
    rclcpp \
    rclcpp-action \
    rclpy \
    tinyxml2-vendor \
    yasmin \
    yasmin-msgs \
    yasmin-ros \
    yasmin-viewer \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    ament-cmake-python-native \
"

ROS_EXPORT_DEPENDS = "\
    ament-index-cpp \
    class-loader \
    pluginlib \
    python3 \
    python3-pybind11 \
    rclcpp \
    rclcpp-action \
    rclpy \
    tinyxml2-vendor \
    yasmin \
    yasmin-msgs \
    yasmin-ros \
    yasmin-viewer \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-index-cpp \
    class-loader \
    pluginlib \
    python3 \
    python3-lxml \
    python3-pybind11 \
    rclcpp \
    rclcpp-action \
    rclpy \
    tinyxml2-vendor \
    yasmin \
    yasmin-msgs \
    yasmin-ros \
    yasmin-viewer \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    action-msgs \
    ament-cmake-gtest \
    ament-cmake-pytest \
    ament-index-python \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/yasmin-release/archive/release/humble/yasmin_factory/6.1.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/yasmin_factory"
SRC_URI = "git://github.com/ros2-gbp/yasmin-release;${ROS_BRANCH};protocol=https"
SRCREV = "c52cd8eb82f91383ae63876139a9367bfca6a348"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

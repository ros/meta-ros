# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Tools and utilities for building and testing NavMaps: a GIS-to-NavMap/Gazebo     generator (given a GPS center and a size in meters), a PointCloud-to-NavMap     mesh builder, and a NavMap file publisher for RViz2."
AUTHOR = "Francisco Martín Rico <fmrico@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "Apache License, Version 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=e8978a5103d23266fc6f8ec03dc9eb16"

ROS_CN = "NavMap"
ROS_BPN = "navmap_tools"

ROS_BUILD_DEPENDS = "\
    navmap-core \
    navmap-ros \
    navmap-ros-interfaces \
    pcl-conversions \
    rclcpp \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    ament-cmake-python-native \
"

ROS_EXPORT_DEPENDS = "\
    navmap-core \
    navmap-ros \
    navmap-ros-interfaces \
    pcl-conversions \
    rclcpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-index-python \
    nav-msgs \
    navmap-core \
    navmap-ros \
    navmap-ros-interfaces \
    pcl-conversions \
    python3-numpy \
    python3-pillow \
    python3-platformdirs \
    python3-pyproj \
    python3-requests \
    rclcpp \
    rclpy \
    sensor-msgs \
    sensor-msgs-py \
    tf2-ros-py \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-cmake-pytest \
    ament-copyright \
    ament-flake8 \
    ament-lint-auto \
    ament-lint-common \
    ament-pep257 \
    ament-xmllint \
    python3-pytest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/EasyNavigation/NavMap-release/archive/release/humble/navmap_tools/0.6.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/navmap_tools"
SRC_URI = "git://github.com/EasyNavigation/NavMap-release;${ROS_BRANCH};protocol=https"
SRCREV = "91f731e4f9079f259c94474db9a4033ea5464633"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

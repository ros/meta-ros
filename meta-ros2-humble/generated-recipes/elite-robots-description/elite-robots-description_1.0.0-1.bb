# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "URDF description for Elite Robots"
AUTHOR = "chenshichao <chenshichao@elibot.cn>"
ROS_AUTHOR = "Chen Shichao"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=16;endline=16;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "elite_robots_description"
ROS_BPN = "elite_robots_description"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    joint-state-publisher-gui \
    launch \
    launch-ros \
    pose-broadcaster \
    robot-state-publisher \
    rviz2 \
    urdf \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-pytest \
    launch-testing-ament-cmake \
    launch-testing-ros \
    urdfdom \
    xacro \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/EliteRobots/Elite_Robots_CS_ROS2_Description-release/archive/release/humble/elite_robots_description/1.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/elite_robots_description"
SRC_URI = "git://github.com/EliteRobots/Elite_Robots_CS_ROS2_Description-release;${ROS_BRANCH};protocol=https"
SRCREV = "358f5d5eb232675da73b5e7af487c79a407e6a98"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

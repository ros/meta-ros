# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "The depthai_bridge_v3 package"
AUTHOR = "Matevz Morato <matevz.morato@luxonis.com>"
ROS_AUTHOR = "Sachin Guruswamy"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=92566b45c3390e5178465bcaade208b7"

ROS_CN = "depthai_ros_v3"
ROS_BPN = "depthai_bridge_v3"

ROS_BUILD_DEPENDS = " \
    boost \
    camera-info-manager \
    composition-interfaces \
    cv-bridge \
    depthai-ros-msgs-v3 \
    depthai-v3 \
    ffmpeg-image-transport-msgs \
    image-transport \
    nav-msgs \
    opencv \
    rclcpp \
    ros-environment \
    sensor-msgs \
    std-msgs \
    stereo-msgs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
    vision-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    boost \
    camera-info-manager \
    composition-interfaces \
    cv-bridge \
    depthai-ros-msgs-v3 \
    depthai-v3 \
    ffmpeg-image-transport-msgs \
    image-transport \
    nav-msgs \
    opencv \
    rclcpp \
    ros-environment \
    sensor-msgs \
    std-msgs \
    stereo-msgs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
    vision-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    boost \
    camera-info-manager \
    composition-interfaces \
    cv-bridge \
    depthai-ros-msgs-v3 \
    depthai-v3 \
    ffmpeg-image-transport-msgs \
    image-transport \
    nav-msgs \
    opencv \
    rclcpp \
    robot-state-publisher \
    ros-environment \
    sensor-msgs \
    std-msgs \
    stereo-msgs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
    vision-msgs \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-gtest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/luxonis/depthai-ros-v3-release/archive/release/humble/depthai_bridge_v3/3.1.1-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/depthai_bridge_v3"
SRC_URI = "git://github.com/luxonis/depthai-ros-v3-release;${ROS_BRANCH};protocol=https"
SRCREV = "1e063235e2d60a81c37da7e4b8b3f64a310e00c8"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "roscontrol controller package conputing a linear feedback. The user needs     to provide a model of the robot and a list of controlled joint and the     controller computes a linear feedback on the user defined state."
AUTHOR = "Guilhem Saurel <guilhem.saurel@laas.fr>"
ROS_AUTHOR = "Maximilien Naveau"
HOMEPAGE = "https://github.com/loco-3d/linear-feedback-controller"
SECTION = "devel"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=2ac6d860cb803e383c653bdc1d2758c1"

ROS_CN = "linear_feedback_controller"
ROS_BPN = "linear_feedback_controller"

ROS_BUILD_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libexpected-dev} \
    control-toolbox \
    controller-interface \
    fmt \
    generate-parameter-library \
    hardware-interface \
    jrl-cmakemodules \
    libeigen \
    linear-feedback-controller-msgs \
    message-filters \
    nav-msgs \
    pal-statistics \
    pinocchio \
    pluginlib \
    rcl \
    rclcpp \
    rclcpp-lifecycle \
    realtime-tools \
    sensor-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native \
    ament-cmake-python-native \
"

ROS_EXPORT_DEPENDS = "\
    control-toolbox \
    controller-interface \
    generate-parameter-library \
    hardware-interface \
    libeigen \
    linear-feedback-controller-msgs \
    message-filters \
    nav-msgs \
    pal-statistics \
    pinocchio \
    pluginlib \
    rcl \
    rclcpp \
    rclcpp-lifecycle \
    realtime-tools \
    sensor-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-liboctomap-dev} \
    action-msgs \
    ament-cmake \
    ament-cmake-core \
    ament-cmake-export-definitions \
    ament-cmake-export-dependencies \
    ament-cmake-export-include-directories \
    ament-cmake-export-interfaces \
    ament-cmake-export-libraries \
    ament-cmake-export-link-flags \
    ament-cmake-export-targets \
    ament-cmake-gen-version-h \
    ament-cmake-libraries \
    ament-cmake-python \
    ament-cmake-target-dependencies \
    ament-cmake-test \
    ament-cmake-version \
    ament-index-cpp \
    assimp \
    boost \
    builtin-interfaces \
    class-loader \
    coal \
    console-bridge \
    console-bridge-vendor \
    control-msgs \
    doxygen \
    eigenpy \
    filters \
    gcc-runtime \
    geometry-msgs \
    libcap \
    libstatistics-collector \
    libtinyxml2 \
    libyaml \
    libyaml-vendor \
    lifecycle-msgs \
    pal-statistics-msgs \
    parameter-traits \
    pkgconfig \
    python3 \
    python3-numpy \
    python3-scipy \
    rcl-action \
    rcl-interfaces \
    rcl-lifecycle \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp-action \
    rclcpp-components \
    rclpy \
    rcpputils \
    rcutils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    ros-environment \
    rosgraph-msgs \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-interface \
    rsl \
    statistics-msgs \
    std-msgs \
    tcb-span \
    tf2 \
    tf2-eigen \
    tf2-msgs \
    tf2-ros \
    tinyxml2-vendor \
    tl-expected \
    tracetools \
    trajectory-msgs \
    unique-identifier-msgs \
    urdfdom \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-gmock-native \
    ament-cmake-gtest-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-package-native \
    cmake-native \
    generate-parameter-library-py-native \
    gmock-vendor-native \
    gtest-native \
    gtest-vendor-native \
    python3-catkin-pkg-native \
    python3-importlib-metadata-native \
    python3-jinja2-native \
    python3-native \
    python3-pyyaml-native \
    python3-setuptools-native \
    python3-typeguard-native \
"

ROS_EXEC_DEPENDS = "\
    control-toolbox \
    controller-interface \
    generate-parameter-library \
    hardware-interface \
    linear-feedback-controller-msgs \
    message-filters \
    nav-msgs \
    pal-statistics \
    pinocchio \
    pluginlib \
    rcl \
    rclcpp \
    rclcpp-lifecycle \
    realtime-tools \
    sensor-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    gmock-vendor \
    gtest-vendor \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/linear-feedback-controller-release/archive/release/humble/linear_feedback_controller/4.0.1-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/linear_feedback_controller"
SRC_URI = "git://github.com/ros2-gbp/linear-feedback-controller-release;${ROS_BRANCH};protocol=https"
SRCREV = "32262fe30bade73b11fffd5a77b5cc605fd0170f"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

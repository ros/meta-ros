# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Fleet Adapter package for RMF fleets."
AUTHOR = "Grey <grey@openrobotics.org>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "rmf_ros2"
ROS_BPN = "rmf_fleet_adapter"

ROS_BUILD_DEPENDS = "\
    libeigen \
    nlohmann-json \
    nlohmann-json-schema-validator-vendor \
    rclcpp \
    rclcpp-components \
    rmf-api-msgs \
    rmf-battery \
    rmf-building-map-msgs \
    rmf-dispenser-msgs \
    rmf-door-msgs \
    rmf-fleet-msgs \
    rmf-ingestor-msgs \
    rmf-lift-msgs \
    rmf-task \
    rmf-task-msgs \
    rmf-task-ros2 \
    rmf-task-sequence \
    rmf-traffic \
    rmf-traffic-ros2 \
    rmf-utils \
    rmf-websocket \
    std-msgs \
    yaml-cpp \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    nlohmann-json \
    nlohmann-json-schema-validator-vendor \
    rclcpp \
    rclcpp-components \
    rmf-api-msgs \
    rmf-battery \
    rmf-building-map-msgs \
    rmf-dispenser-msgs \
    rmf-door-msgs \
    rmf-fleet-msgs \
    rmf-ingestor-msgs \
    rmf-lift-msgs \
    rmf-task \
    rmf-task-msgs \
    rmf-task-ros2 \
    rmf-task-sequence \
    rmf-traffic \
    rmf-traffic-ros2 \
    rmf-utils \
    rmf-websocket \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ament-index-cpp \
    builtin-interfaces \
    libccd \
    libstatistics-collector \
    libyaml \
    libyaml-vendor \
    proj \
    python3-jinja2 \
    python3-jsonschema \
    rcl \
    rcl-interfaces \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rcpputils \
    rcutils \
    rmf-site-map-msgs \
    rmf-traffic-msgs \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-interface \
    statistics-msgs \
    tracetools \
    websocketpp \
    zlib \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-package-native \
    cmake-native \
    eigen3-cmake-module-native \
    python3-catkin-pkg-native \
    python3-importlib-metadata-native \
    python3-native \
    python3-setuptools-native \
"

ROS_EXEC_DEPENDS = "\
    nlohmann-json \
    nlohmann-json-schema-validator-vendor \
    rclcpp \
    rclcpp-components \
    rmf-api-msgs \
    rmf-battery \
    rmf-building-map-msgs \
    rmf-dispenser-msgs \
    rmf-door-msgs \
    rmf-fleet-msgs \
    rmf-ingestor-msgs \
    rmf-lift-msgs \
    rmf-task \
    rmf-task-msgs \
    rmf-task-ros2 \
    rmf-task-sequence \
    rmf-traffic \
    rmf-traffic-ros2 \
    rmf-utils \
    rmf-websocket \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-catch2 \
    ament-cmake-uncrustify \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/rmf_ros2-release/archive/release/humble/rmf_fleet_adapter/2.1.8-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/rmf_fleet_adapter"
SRC_URI = "git://github.com/ros2-gbp/rmf_ros2-release;${ROS_BRANCH};protocol=https"
SRCREV = "199474329d772efa8853a327a4aa6978193bd64d"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Streaming of OptiTrack mocap data to tf     <p>     This package contains a node that translates motion capture data from an     OptiTrack rig to tf transforms, poses and 2D poses. The node receives     packets that are streamed by a NatNet compliant source, decodes them and     broadcasts the poses of configured rigid bodies as tf transforms, poses,     and/or 2D poses.     </p>     <p>     Currently, this node supports the NatNet streaming protocol v3.0     </p>     <p>     Copyright (c) 2013, Clearpath Robotics<br/>     Copyright (c) 2010, University of Bonn, Computer Science Institute VI<br/>     All rights reserved.     </p>"
AUTHOR = "Tony Baltovski <tony@baltovski.ca>"
ROS_AUTHOR = "Kathrin Gräve <graeve@ais.uni-bonn.de>"
HOMEPAGE = "http://ros.org/wiki/mocap_optitrack"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=27;endline=27;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "mocap_optitrack"
ROS_BPN = "mocap_optitrack"

ROS_BUILD_DEPENDS = "\
    geometry-msgs \
    nav-msgs \
    rclcpp \
    tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    geometry-msgs \
    nav-msgs \
    rclcpp \
    tf2-ros \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    action-msgs \
    ament-cmake \
    ament-cmake-core \
    ament-cmake-export-definitions \
    ament-cmake-export-dependencies \
    ament-cmake-export-include-directories \
    ament-cmake-export-interfaces \
    ament-cmake-export-libraries \
    ament-cmake-export-link-flags \
    ament-cmake-export-targets \
    ament-cmake-gen-version-h \
    ament-cmake-libraries \
    ament-cmake-python \
    ament-cmake-target-dependencies \
    ament-cmake-test \
    ament-cmake-version \
    ament-index-cpp \
    builtin-interfaces \
    console-bridge \
    console-bridge-vendor \
    gcc-runtime \
    libstatistics-collector \
    libyaml \
    libyaml-vendor \
    message-filters \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp-action \
    rclcpp-components \
    rcpputils \
    rcutils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-interface \
    statistics-msgs \
    std-msgs \
    tf2 \
    tf2-msgs \
    tracetools \
    unique-identifier-msgs \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-package-native \
    cmake-native \
    python3-catkin-pkg-native \
    python3-importlib-metadata-native \
    python3-native \
    python3-setuptools-native \
"

ROS_EXEC_DEPENDS = "\
    geometry-msgs \
    nav-msgs \
    rclcpp \
    tf2-ros \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/mocap_optitrack-release/archive/release/humble/mocap_optitrack/1.0.1-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/mocap_optitrack"
SRC_URI = "git://github.com/ros2-gbp/mocap_optitrack-release;${ROS_BRANCH};protocol=https"
SRCREV = "8d2a36dc5e58aa0add327ea15b19ff88b22c3f9a"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

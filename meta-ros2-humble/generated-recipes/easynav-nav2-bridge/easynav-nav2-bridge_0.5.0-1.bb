# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Easy Navigation: Nav2 bridge exposing a nav2_msgs/action/NavigateToPose action server backed by EasyNav."
AUTHOR = "Francisco Martín Rico <fmrico@gmail.com>"
ROS_AUTHOR = "Francisco Martín Rico"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "easynav_nav2_bridge"
ROS_BPN = "easynav_nav2_bridge"

ROS_BUILD_DEPENDS = "\
    easynav-interfaces \
    easynav-system \
    geometry-msgs \
    nav2-msgs \
    rclcpp \
    rclcpp-action \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    easynav-interfaces \
    easynav-system \
    geometry-msgs \
    nav2-msgs \
    rclcpp \
    rclcpp-action \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    easynav-interfaces \
    easynav-system \
    geometry-msgs \
    nav2-msgs \
    rclcpp \
    rclcpp-action \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    action-msgs \
    ament-cmake-gtest \
    ament-lint-auto \
    ament-lint-common \
    easynav-common \
    nav-msgs \
    rclcpp-lifecycle \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/EasyNavigation/easynav_nav2_bridge-release/archive/release/humble/easynav_nav2_bridge/0.5.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/easynav_nav2_bridge"
SRC_URI = "git://github.com/EasyNavigation/easynav_nav2_bridge-release;${ROS_BRANCH};protocol=https"
SRCREV = "79c51afdf3ca88230d2cfc75c6a98ff943bd6ca1"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

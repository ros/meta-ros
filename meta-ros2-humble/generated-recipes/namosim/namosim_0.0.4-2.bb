# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "A navigation planner for Navigation Among Movable Obstacles (NAMO)"
AUTHOR = "David Brown <david.brown@inria.fr>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "namosim"
ROS_BPN = "namosim"

ROS_BUILD_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-jupyter-notebook} \
    ${ROS_UNRESOLVED_DEP-python3-cairosvg} \
    ${ROS_UNRESOLVED_DEP-python3-jsonpickle} \
    ${ROS_UNRESOLVED_DEP-python3-skimage} \
    ${ROS_UNRESOLVED_DEP-python3-typer} \
    cairo \
    geometry-msgs \
    grid-map \
    grid-map-msgs \
    opencv \
    python3-bidict \
    python3-black \
    python3-matplotlib \
    python3-numpy \
    python3-pandas \
    python3-pillow \
    python3-pre-commit \
    python3-pydantic \
    python3-pytest \
    python3-pytest-cov \
    python3-requests \
    python3-shapely \
    python3-tkinter \
    python3-typing-extensions \
    rclpy \
"

ROS_BUILDTOOL_DEPENDS = ""

ROS_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-jupyter-notebook} \
    ${ROS_UNRESOLVED_DEP-python3-cairosvg} \
    ${ROS_UNRESOLVED_DEP-python3-jsonpickle} \
    ${ROS_UNRESOLVED_DEP-python3-skimage} \
    ${ROS_UNRESOLVED_DEP-python3-typer} \
    cairo \
    geometry-msgs \
    grid-map \
    grid-map-msgs \
    opencv \
    python3-bidict \
    python3-black \
    python3-matplotlib \
    python3-numpy \
    python3-pandas \
    python3-pillow \
    python3-pre-commit \
    python3-pydantic \
    python3-pytest \
    python3-pytest-cov \
    python3-requests \
    python3-shapely \
    python3-tkinter \
    python3-typing-extensions \
    rclpy \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    action-msgs \
    ament-index-cpp \
    builtin-interfaces \
    libstatistics-collector \
    libyaml \
    libyaml-vendor \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-lifecycle \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp \
    rcpputils \
    rcutils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-default-generators \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-interface \
    statistics-msgs \
    std-msgs \
    tracetools \
    unique-identifier-msgs \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-gmock-native \
    ament-cmake-gtest-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-native \
    ament-cmake-pytest-native \
    ament-cmake-python-native \
    ament-cmake-ros-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-index-python-native \
    ament-package-native \
    cmake-native \
    domain-coordinator-native \
    fastcdr-native \
    fastrtps-cmake-module-native \
    gmock-vendor-native \
    gtest-native \
    gtest-vendor-native \
    python-cmake-module-native \
    python3-catkin-pkg-native \
    python3-empy-native \
    python3-importlib-metadata-native \
    python3-native \
    python3-pytest-native \
    python3-setuptools-native \
    rcpputils-native \
    rcutils-native \
    rmw-native \
    ros-environment-native \
    rosidl-cmake-native \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    rosidl-generator-py-native \
    rosidl-generator-rs-native \
    rosidl-runtime-c-native \
    rosidl-runtime-cpp-native \
    rosidl-typesupport-c-native \
    rosidl-typesupport-cpp-native \
    rosidl-typesupport-fastrtps-c-native \
    rosidl-typesupport-fastrtps-cpp-native \
    rosidl-typesupport-interface-native \
    rosidl-typesupport-introspection-c-native \
    rosidl-typesupport-introspection-cpp-native \
"

ROS_EXEC_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-jupyter-notebook} \
    ${ROS_UNRESOLVED_DEP-python3-cairosvg} \
    ${ROS_UNRESOLVED_DEP-python3-jsonpickle} \
    ${ROS_UNRESOLVED_DEP-python3-skimage} \
    ${ROS_UNRESOLVED_DEP-python3-typer} \
    cairo \
    geometry-msgs \
    grid-map \
    grid-map-msgs \
    opencv \
    python3-bidict \
    python3-black \
    python3-matplotlib \
    python3-numpy \
    python3-pandas \
    python3-pillow \
    python3-pre-commit \
    python3-pydantic \
    python3-pytest \
    python3-pytest-cov \
    python3-requests \
    python3-shapely \
    python3-tkinter \
    python3-typing-extensions \
    rclpy \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/namosim-release/archive/release/humble/namosim/0.0.4-2.tar.gz
ROS_BRANCH ?= "branch=release/humble/namosim"
SRC_URI = "git://github.com/ros2-gbp/namosim-release;${ROS_BRANCH};protocol=https"
SRCREV = "41e6c5d0edd4064c3a145d95c15061d754c31aae"

ROS_BUILD_TYPE = "ament_python"

inherit ros_${ROS_BUILD_TYPE}

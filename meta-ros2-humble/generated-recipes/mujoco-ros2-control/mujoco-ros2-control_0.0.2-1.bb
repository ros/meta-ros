# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "ros2_control wrapper for the MuJoCo Simulate application"
AUTHOR = "Nathan Dunkelberger <nathan.b.dunkelberger@nasa.gov>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=15;endline=15;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "mujoco_ros2_control"
ROS_BPN = "mujoco_ros2_control"

ROS_BUILD_DEPENDS = " \
    backward-ros \
    control-toolbox \
    controller-manager \
    fmt \
    glfw \
    hardware-interface \
    mujoco-ros2-control-msgs \
    mujoco-ros2-control-plugins \
    mujoco-vendor \
    nav-msgs \
    pluginlib \
    python3-pykdl \
    rclcpp \
    rclcpp-lifecycle \
    ros2-control-cmake \
    sensor-msgs \
    transmission-interface \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
    ament-cmake-python-native \
    git-native \
"

ROS_EXPORT_DEPENDS = " \
    backward-ros \
    control-toolbox \
    controller-manager \
    fmt \
    glfw \
    hardware-interface \
    mujoco-ros2-control-msgs \
    mujoco-ros2-control-plugins \
    mujoco-vendor \
    nav-msgs \
    pluginlib \
    python3-pykdl \
    rclcpp \
    rclcpp-lifecycle \
    sensor-msgs \
    transmission-interface \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    backward-ros \
    control-toolbox \
    controller-manager \
    fmt \
    glfw \
    hardware-interface \
    mujoco-ros2-control-msgs \
    mujoco-ros2-control-plugins \
    mujoco-vendor \
    nav-msgs \
    pluginlib \
    python3 \
    python3-pip \
    python3-pykdl \
    rclcpp \
    rclcpp-lifecycle \
    sensor-msgs \
    transmission-interface \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-gtest \
    ament-cmake-pytest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/mujoco_ros2_control-release/archive/release/humble/mujoco_ros2_control/0.0.2-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/mujoco_ros2_control"
SRC_URI = "git://github.com/ros2-gbp/mujoco_ros2_control-release;${ROS_BRANCH};protocol=https"
SRCREV = "0d32f4668ad943a715b2c40f3865e873554eef13"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

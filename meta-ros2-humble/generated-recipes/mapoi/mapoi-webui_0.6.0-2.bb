# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Web UI for mapoi - POI editing, navigation, and robot monitoring"
AUTHOR = "Shunsuke Kimura <kimura.shunsuke@shimz.co.jp>"
ROS_AUTHOR = "Shunsuke Kimura <kimura.shunsuke@shimz.co.jp>"
HOMEPAGE = "https://github.com/shimz-robotics/mapoi"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "mapoi"
ROS_BPN = "mapoi_webui"

ROS_BUILD_DEPENDS = "\
    mapoi-interfaces \
    rclpy \
    std-msgs \
    std-srvs \
    tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    ament-cmake-python-native \
"

ROS_EXPORT_DEPENDS = "\
    mapoi-interfaces \
    rclpy \
    std-msgs \
    std-srvs \
    tf2-ros \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    mapoi-interfaces \
    mapoi-server \
    python3-flask \
    python3-pillow \
    python3-pyyaml \
    rclpy \
    std-msgs \
    std-srvs \
    tf2-ros \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-pytest \
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/shimz-robotics/mapoi-release/archive/release/humble/mapoi_webui/0.6.0-2.tar.gz
ROS_BRANCH ?= "branch=release/humble/mapoi_webui"
SRC_URI = "git://github.com/shimz-robotics/mapoi-release;${ROS_BRANCH};protocol=https"
SRCREV = "5b99c549d88f7de5ac723d8532275d9b56757413"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

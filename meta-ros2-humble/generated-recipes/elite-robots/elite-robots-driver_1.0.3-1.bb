# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Elite CS series robot ros2 driver"
AUTHOR = "Yan <yanxiaojia@elibot.cn>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "elite_robots"
ROS_BPN = "elite_robots_driver"

ROS_BUILD_DEPENDS = "\
    backward-ros \
    control-msgs \
    controller-manager \
    controller-manager-msgs \
    elite-cs-series-sdk \
    elite-robots-dashboard-msgs \
    elite-robots-description \
    elite-robots-msgs \
    geometry-msgs \
    hardware-interface \
    launch \
    launch-ros \
    pluginlib \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rclcpp-lifecycle \
    rclpy \
    realtime-tools \
    ros2-control \
    ros2-controllers \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf2-geometry-msgs \
    trajectory-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    backward-ros \
    control-msgs \
    controller-manager \
    controller-manager-msgs \
    elite-cs-series-sdk \
    elite-robots-dashboard-msgs \
    elite-robots-description \
    elite-robots-msgs \
    geometry-msgs \
    hardware-interface \
    launch \
    launch-ros \
    pluginlib \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rclcpp-lifecycle \
    rclpy \
    realtime-tools \
    ros2-control \
    ros2-controllers \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf2-geometry-msgs \
    trajectory-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    backward-ros \
    builtin-interfaces \
    control-msgs \
    controller-manager \
    controller-manager-msgs \
    elite-cs-series-sdk \
    elite-robots-dashboard-msgs \
    elite-robots-description \
    elite-robots-msgs \
    force-torque-sensor-broadcaster \
    geometry-msgs \
    hardware-interface \
    joint-state-broadcaster \
    joint-state-publisher \
    joint-trajectory-controller \
    launch \
    launch-ros \
    pluginlib \
    position-controllers \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rclcpp-lifecycle \
    rclpy \
    realtime-tools \
    robot-state-publisher \
    ros2-control \
    ros2-controllers \
    ros2-controllers-test-nodes \
    rviz2 \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf2-geometry-msgs \
    trajectory-msgs \
    urdf \
    velocity-controllers \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
    launch-testing-ament-cmake \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/EliteRobots/Elite_Robots_CS_ROS2_Driver-release/archive/release/humble/elite_robots_driver/1.0.3-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/elite_robots_driver"
SRC_URI = "git://github.com/EliteRobots/Elite_Robots_CS_ROS2_Driver-release;${ROS_BRANCH};protocol=https"
SRCREV = "76b05495252a547436af995d4989fd9252c3ebde"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

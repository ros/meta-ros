# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Provides controllers that use the speed scaling interface of Elite CS series robots."
AUTHOR = "Yan <yanxiaojia@elibot.cn>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "elite_robots"
ROS_BPN = "elite_robots_controllers"

ROS_BUILD_DEPENDS = "\
    angles \
    controller-interface \
    elite-robots-msgs \
    generate-parameter-library \
    hardware-interface \
    joint-trajectory-controller \
    lifecycle-msgs \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    rcpputils \
    rcutils \
    realtime-tools \
    std-msgs \
    std-srvs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    angles \
    controller-interface \
    elite-robots-msgs \
    generate-parameter-library \
    hardware-interface \
    joint-trajectory-controller \
    lifecycle-msgs \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    rcpputils \
    rcutils \
    realtime-tools \
    std-msgs \
    std-srvs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    angles \
    controller-interface \
    elite-robots-msgs \
    generate-parameter-library \
    hardware-interface \
    joint-trajectory-controller \
    lifecycle-msgs \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    rcpputils \
    rcutils \
    realtime-tools \
    std-msgs \
    std-srvs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/EliteRobots/Elite_Robots_CS_ROS2_Driver-release/archive/release/humble/elite_robots_controllers/1.0.3-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/elite_robots_controllers"
SRC_URI = "git://github.com/EliteRobots/Elite_Robots_CS_ROS2_Driver-release;${ROS_BRANCH};protocol=https"
SRCREV = "df4a8c1f80c72cf2945ed99c1889ec257bcc8ce7"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "CLI tool to convert MRPT rawlog datasets into ROS 2 bags (mcap, sqlite3)."
AUTHOR = "Jose Luis Blanco-Claraco <joseluisblancoc@gmail.com>"
HOMEPAGE = "https://github.com/mrpt/mrpt_ros_bridge"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "mrpt_ros_bridge"
ROS_BPN = "rawlog2rosbag"

ROS_BUILD_DEPENDS = "\
    cli11 \
    geometry-msgs \
    mrpt-libros-bridge \
    mrpt-maps \
    mrpt-obs \
    nav-msgs \
    rclcpp \
    rosbag2-cpp \
    rosbag2-storage \
    sensor-msgs \
    std-msgs \
    tf2-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    cli11 \
    geometry-msgs \
    mrpt-libros-bridge \
    mrpt-maps \
    mrpt-obs \
    nav-msgs \
    rclcpp \
    rosbag2-cpp \
    rosbag2-storage \
    sensor-msgs \
    std-msgs \
    tf2-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    cli11 \
    geometry-msgs \
    mrpt-libros-bridge \
    mrpt-maps \
    mrpt-obs \
    nav-msgs \
    rclcpp \
    rosbag2-cpp \
    rosbag2-storage \
    rosbag2-storage-default-plugins \
    rosbag2-storage-mcap \
    sensor-msgs \
    std-msgs \
    tf2-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-cmake-lint-cmake \
    ament-cmake-xmllint \
    ament-lint-auto \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/mrpt_ros_bridge-release/archive/release/humble/rawlog2rosbag/4.2.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/rawlog2rosbag"
SRC_URI = "git://github.com/ros2-gbp/mrpt_ros_bridge-release;${ROS_BRANCH};protocol=https"
SRCREV = "2a4243af65b6df26a873c4d3df92a4e22b0db274"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Efficient Task Space Inverse Dynamics (TSID) based on Pinocchio"
AUTHOR = "Guilhem Saurel <guilhem.saurel@laas.fr>"
ROS_AUTHOR = "Andrea Del Prete"
HOMEPAGE = "https://github.com/stack-of-tasks/tsid"
SECTION = "devel"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=2ac6d860cb803e383c653bdc1d2758c1"

ROS_CN = "tsid"
ROS_BPN = "tsid"

ROS_BUILD_DEPENDS = "\
    boost \
    doxygen \
    eigenpy \
    eiquadprog \
    git \
    graphviz \
    jrl-cmakemodules \
    pinocchio \
"

ROS_BUILDTOOL_DEPENDS = "\
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    boost \
    eigenpy \
    eiquadprog \
    graphviz \
    pinocchio \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-liboctomap-dev} \
    assimp \
    coal \
    libeigen \
    pkgconfig \
    python3 \
    python3-numpy \
    python3-scipy \
    ros-environment \
    urdfdom \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-cmake \
    boost \
    eigenpy \
    eiquadprog \
    graphviz \
    pinocchio \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/tsid-release/archive/release/humble/tsid/1.10.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/tsid"
SRC_URI = "git://github.com/ros2-gbp/tsid-release;${ROS_BRANCH};protocol=https"
SRCREV = "86a09935afd90eb081f68f327f14cabac2a000d4"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Efficient Task Space Inverse Dynamics (TSID) based on Pinocchio"
AUTHOR = "Guilhem Saurel <guilhem.saurel@laas.fr>"
ROS_AUTHOR = "Andrea Del Prete"
HOMEPAGE = "https://github.com/stack-of-tasks/tsid"
SECTION = "devel"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=2ac6d860cb803e383c653bdc1d2758c1"

ROS_CN = "tsid"
ROS_BPN = "tsid"

ROS_BUILD_DEPENDS = " \
    boost \
    doxygen \
    eigenpy \
    eiquadprog \
    git \
    graphviz \
    pinocchio \
"

ROS_BUILDTOOL_DEPENDS = " \
    cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    boost \
    eigenpy \
    eiquadprog \
    graphviz \
    pinocchio \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ament-cmake \
    boost \
    eigenpy \
    eiquadprog \
    graphviz \
    pinocchio \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/tsid-release/archive/release/humble/tsid/1.9.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/tsid"
SRC_URI = "git://github.com/ros2-gbp/tsid-release;${ROS_BRANCH};protocol=https"
SRCREV = "3eab18df8160eaba1598d8bd4ed9cbe43842dd1f"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Raspberry Pi Mouse examples"
AUTHOR = "RT Corporation <shop@rt-net.jp>"
ROS_AUTHOR = "ShotaAk <s.aoki@rt-net.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "raspimouse_ros2_examples"
ROS_BPN = "raspimouse_ros2_examples"

ROS_BUILD_DEPENDS = " \
    cv-bridge \
    geometry-msgs \
    hls-lfcd-lds-driver \
    joy-linux \
    nav2-map-server \
    opencv \
    raspimouse \
    raspimouse-msgs \
    rclcpp \
    rclcpp-components \
    rclcpp-lifecycle \
    rt-usb-9axisimu-driver \
    sensor-msgs \
    slam-toolbox \
    std-msgs \
    std-srvs \
    usb-cam \
    v4l-utils \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    cv-bridge \
    geometry-msgs \
    hls-lfcd-lds-driver \
    joy-linux \
    nav2-map-server \
    opencv \
    raspimouse \
    raspimouse-msgs \
    rclcpp \
    rclcpp-components \
    rclcpp-lifecycle \
    rt-usb-9axisimu-driver \
    sensor-msgs \
    slam-toolbox \
    std-msgs \
    std-srvs \
    usb-cam \
    v4l-utils \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    cv-bridge \
    geometry-msgs \
    hls-lfcd-lds-driver \
    joy-linux \
    nav2-map-server \
    opencv \
    raspimouse \
    raspimouse-msgs \
    rclcpp \
    rclcpp-components \
    rclcpp-lifecycle \
    rt-usb-9axisimu-driver \
    sensor-msgs \
    slam-toolbox \
    std-msgs \
    std-srvs \
    usb-cam \
    v4l-utils \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/raspimouse_ros2_examples-release/archive/release/humble/raspimouse_ros2_examples/2.2.0-2.tar.gz
ROS_BRANCH ?= "branch=release/humble/raspimouse_ros2_examples"
SRC_URI = "git://github.com/ros2-gbp/raspimouse_ros2_examples-release;${ROS_BRANCH};protocol=https"
SRCREV = "ad8a3cfc696b678883c4aaa488b0e6b660df28d9"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

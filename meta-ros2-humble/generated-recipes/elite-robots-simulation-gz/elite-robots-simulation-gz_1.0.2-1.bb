# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Example and configuration files for Gazebo simulation of Elite Robots robot manipulators."
AUTHOR = "chenshichao <chenshichao@elibot.cn>"
ROS_AUTHOR = "Chen Shichao"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=16;endline=16;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "elite_robots_simulation_gz"
ROS_BPN = "elite_robots_simulation_gz"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    builtin-interfaces \
    control-msgs \
    controller-manager \
    elite-robots-description \
    elite-robots-moveit-config \
    ign-ros2-control \
    joint-state-broadcaster \
    joint-state-publisher \
    joint-trajectory-controller \
    launch \
    launch-ros \
    position-controllers \
    python3-pyyaml \
    rclpy \
    robot-state-publisher \
    ros-gz-bridge \
    ros-gz-sim \
    rosgraph-msgs \
    rviz2 \
    sensor-msgs \
    trajectory-msgs \
    urdf \
    velocity-controllers \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/EliteRobots/Elite_Robots_CS_ROS2_GZ_Simulation-release/archive/release/humble/elite_robots_simulation_gz/1.0.2-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/elite_robots_simulation_gz"
SRC_URI = "git://github.com/EliteRobots/Elite_Robots_CS_ROS2_GZ_Simulation-release;${ROS_BRANCH};protocol=https"
SRCREV = "e168935dc14d81e4d4147d3d82cf5511915ebc1a"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

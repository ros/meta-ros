# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "RViz2 plugin for 2D overlays in the 3D view for Autoware."
AUTHOR = "Khalil Selyan <khalil@leodrive.ai>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_rviz_plugins"
ROS_BPN = "autoware_overlay_rviz_plugin"

ROS_BUILD_DEPENDS = "\
    ament-index-cpp \
    autoware-internal-planning-msgs \
    autoware-perception-msgs \
    autoware-vehicle-msgs \
    boost \
    rviz-2d-overlay-msgs \
    rviz-2d-overlay-plugins \
    rviz-common \
    rviz-ogre-vendor \
    rviz-rendering \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native \
"

ROS_EXPORT_DEPENDS = "\
    ament-index-cpp \
    autoware-internal-planning-msgs \
    autoware-perception-msgs \
    autoware-vehicle-msgs \
    boost \
    rviz-2d-overlay-msgs \
    rviz-2d-overlay-plugins \
    rviz-common \
    rviz-ogre-vendor \
    rviz-rendering \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    action-msgs \
    ament-cmake \
    ament-cmake-core \
    ament-cmake-export-definitions \
    ament-cmake-export-dependencies \
    ament-cmake-export-include-directories \
    ament-cmake-export-interfaces \
    ament-cmake-export-libraries \
    ament-cmake-export-link-flags \
    ament-cmake-export-targets \
    ament-cmake-gen-version-h \
    ament-cmake-libraries \
    ament-cmake-python \
    ament-cmake-target-dependencies \
    ament-cmake-test \
    ament-cmake-version \
    ament-index-python \
    autoware-common-msgs \
    autoware-planning-msgs \
    builtin-interfaces \
    class-loader \
    console-bridge \
    console-bridge-vendor \
    curl \
    eigen3-cmake-module \
    freetype \
    geometry-msgs \
    glew \
    libcurl-vendor \
    libeigen \
    libstatistics-collector \
    libtinyxml2 \
    libx11 \
    libxaw \
    libxrandr \
    libyaml \
    libyaml-vendor \
    mesa \
    message-filters \
    nav-msgs \
    orocos-kdl \
    orocos-kdl-vendor \
    pluginlib \
    qtbase \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rcpputils \
    rcutils \
    resource-retriever \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-interface \
    sensor-msgs \
    statistics-msgs \
    std-msgs \
    tf2 \
    tf2-geometry-msgs \
    tf2-msgs \
    tf2-ros \
    tinyxml2-vendor \
    tracetools \
    unique-identifier-msgs \
    urdf \
    urdf-parser-plugin \
    urdfdom \
    urdfdom-headers \
    yaml-cpp \
    yaml-cpp-vendor \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-gmock-native \
    ament-cmake-gtest-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-package-native \
    cmake-native \
    eigen3-cmake-module-native \
    gmock-vendor-native \
    gtest-native \
    gtest-vendor-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-importlib-metadata-native \
    python3-native \
    python3-setuptools-native \
"

ROS_EXEC_DEPENDS = "\
    ament-index-cpp \
    autoware-internal-planning-msgs \
    autoware-perception-msgs \
    autoware-vehicle-msgs \
    boost \
    rviz-2d-overlay-msgs \
    rviz-2d-overlay-plugins \
    rviz-common \
    rviz-ogre-vendor \
    rviz-rendering \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    autoware-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/autoware_rviz_plugins-release/archive/release/humble/autoware_overlay_rviz_plugin/0.5.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/autoware_overlay_rviz_plugin"
SRC_URI = "git://github.com/ros2-gbp/autoware_rviz_plugins-release;${ROS_BRANCH};protocol=https"
SRCREV = "b3a707f259fd2ac19a26bb177b115c6963d0c52c"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

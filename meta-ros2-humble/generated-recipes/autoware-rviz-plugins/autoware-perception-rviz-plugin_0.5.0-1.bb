# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Contains plugins to visualize object detection outputs"
AUTHOR = "Apex.AI, Inc. <opensource@apex.ai>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache 2.0 & CC BY-SA 4.0"
LICENSE = "Apache-2.0 & CC-BY-SA-4.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=3dce4ba60d7e51ec64f3c3dc18672dd3"

ROS_CN = "autoware_rviz_plugins"
ROS_BPN = "autoware_perception_rviz_plugin"

ROS_BUILD_DEPENDS = "\
    autoware-lanelet2-extension \
    autoware-map-msgs \
    autoware-perception-msgs \
    boost \
    qtbase \
    rviz-common \
    rviz-default-plugins \
    tf2-geometry-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    autoware-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    autoware-lanelet2-extension \
    autoware-map-msgs \
    autoware-perception-msgs \
    rviz-common \
    rviz-default-plugins \
    tf2-geometry-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-ignition-cmake2} \
    ${ROS_UNRESOLVED_DEP-ignition-math6} \
    action-msgs \
    ament-cmake \
    ament-cmake-core \
    ament-cmake-export-definitions \
    ament-cmake-export-dependencies \
    ament-cmake-export-include-directories \
    ament-cmake-export-interfaces \
    ament-cmake-export-libraries \
    ament-cmake-export-link-flags \
    ament-cmake-export-targets \
    ament-cmake-gen-version-h \
    ament-cmake-libraries \
    ament-cmake-python \
    ament-cmake-target-dependencies \
    ament-cmake-test \
    ament-cmake-version \
    ament-index-cpp \
    ament-index-python \
    autoware-common-msgs \
    autoware-planning-msgs \
    boost \
    builtin-interfaces \
    class-loader \
    console-bridge \
    console-bridge-vendor \
    curl \
    eigen3-cmake-module \
    freetype \
    geographic-msgs \
    geographiclib \
    geometry-msgs \
    glew \
    ignition-cmake2-vendor \
    ignition-math6-vendor \
    image-transport \
    interactive-markers \
    lanelet2-core \
    lanelet2-io \
    lanelet2-maps \
    lanelet2-projection \
    lanelet2-routing \
    lanelet2-traffic-rules \
    lanelet2-validation \
    laser-geometry \
    libcurl-vendor \
    libeigen \
    libstatistics-collector \
    libtinyxml2 \
    libx11 \
    libxaw \
    libxrandr \
    libyaml \
    libyaml-vendor \
    map-msgs \
    mesa \
    message-filters \
    nav-msgs \
    orocos-kdl \
    orocos-kdl-vendor \
    pluginlib \
    pugixml \
    range-v3 \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rcpputils \
    rcutils \
    resource-retriever \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-interface \
    rviz-ogre-vendor \
    rviz-rendering \
    sensor-msgs \
    statistics-msgs \
    std-msgs \
    tf2 \
    tf2-msgs \
    tinyxml2-vendor \
    tracetools \
    unique-identifier-msgs \
    urdf \
    urdf-parser-plugin \
    urdfdom \
    urdfdom-headers \
    visualization-msgs \
    yaml-cpp \
    yaml-cpp-vendor \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-auto-native \
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-gmock-native \
    ament-cmake-gtest-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-lint-auto-native \
    ament-package-native \
    cmake-native \
    eigen3-cmake-module-native \
    gmock-vendor-native \
    gtest-native \
    gtest-vendor-native \
    lcov-native \
    mrt-cmake-modules-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-importlib-metadata-native \
    python3-native \
    python3-pyyaml-native \
    python3-rospkg-native \
    python3-setuptools-native \
    ros-environment-native \
"

ROS_EXEC_DEPENDS = "\
    autoware-lanelet2-extension \
    autoware-map-msgs \
    autoware-perception-msgs \
    qtbase \
    rviz-common \
    rviz-default-plugins \
    rviz2 \
    tf2-geometry-msgs \
    tf2-ros \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    autoware-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/autoware_rviz_plugins-release/archive/release/humble/autoware_perception_rviz_plugin/0.5.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/autoware_perception_rviz_plugin"
SRC_URI = "git://github.com/ros2-gbp/autoware_rviz_plugins-release;${ROS_BRANCH};protocol=https"
SRCREV = "d49a4747ef4851fdc7d9770fe7861c94ca63ef2b"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

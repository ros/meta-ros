# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Contains plugins to visualize object detection outputs"
AUTHOR = "Apex.AI, Inc. <opensource@apex.ai>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache 2.0 & CC BY-SA 4.0"
LICENSE = "Apache-2.0 & CC-BY-SA-4.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=3dce4ba60d7e51ec64f3c3dc18672dd3"

ROS_CN = "autoware_rviz_plugins"
ROS_BPN = "autoware_perception_rviz_plugin"

ROS_BUILD_DEPENDS = " \
    autoware-lanelet2-extension \
    autoware-map-msgs \
    autoware-perception-msgs \
    boost \
    qtbase \
    rviz-common \
    rviz-default-plugins \
    tf2-geometry-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
    autoware-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    autoware-lanelet2-extension \
    autoware-map-msgs \
    autoware-perception-msgs \
    rviz-common \
    rviz-default-plugins \
    tf2-geometry-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    autoware-lanelet2-extension \
    autoware-map-msgs \
    autoware-perception-msgs \
    qtbase \
    rviz-common \
    rviz-default-plugins \
    rviz2 \
    tf2-geometry-msgs \
    tf2-ros \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-lint-auto \
    autoware-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/autoware_rviz_plugins-release/archive/release/humble/autoware_perception_rviz_plugin/0.4.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/autoware_perception_rviz_plugin"
SRC_URI = "git://github.com/ros2-gbp/autoware_rviz_plugins-release;${ROS_BRANCH};protocol=https"
SRCREV = "ae8e9fde9d43c7e027f92c82682c711e8dbf3a45"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Depthai ROS Monolithic node."
AUTHOR = "Adam Serafin <adam.serafin@luxonis.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "depthai-ros"
ROS_BPN = "depthai_ros_driver"

ROS_BUILD_DEPENDS = " \
    ament-cmake-auto \
    camera-calibration \
    cv-bridge \
    depthai \
    depthai-bridge \
    depthai-descriptions \
    depthai-examples \
    depthai-ros-msgs \
    diagnostic-msgs \
    diagnostic-updater \
    image-pipeline \
    image-transport \
    image-transport-plugins \
    pluginlib \
    rclcpp \
    rclcpp-components \
    sensor-msgs \
    std-msgs \
    std-srvs \
    vision-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    ament-cmake-auto \
    camera-calibration \
    cv-bridge \
    depthai \
    depthai-bridge \
    depthai-descriptions \
    depthai-examples \
    depthai-ros-msgs \
    diagnostic-msgs \
    diagnostic-updater \
    image-pipeline \
    image-transport \
    image-transport-plugins \
    pluginlib \
    rclcpp \
    rclcpp-components \
    sensor-msgs \
    std-msgs \
    std-srvs \
    vision-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ament-cmake-auto \
    camera-calibration \
    cv-bridge \
    depthai \
    depthai-bridge \
    depthai-descriptions \
    depthai-examples \
    depthai-ros-msgs \
    diagnostic-msgs \
    diagnostic-updater \
    image-pipeline \
    image-transport \
    image-transport-plugins \
    pluginlib \
    rclcpp \
    rclcpp-components \
    sensor-msgs \
    std-msgs \
    std-srvs \
    vision-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/luxonis/depthai-ros-release/archive/release/humble/depthai_ros_driver/2.9.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/depthai_ros_driver"
SRC_URI = "git://github.com/luxonis/depthai-ros-release;${ROS_BRANCH};protocol=https"
SRCREV = "10d71b86477217caa796fe92a5bc3579782d17d6"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

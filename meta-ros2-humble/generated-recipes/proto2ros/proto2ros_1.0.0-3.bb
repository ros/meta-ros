# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Protobuf to ROS 2 interoperability interfaces"
AUTHOR = "Boston Dynamics AI Institute <opensource@theaiinstitute.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "proto2ros"
ROS_BPN = "proto2ros"

ROS_BUILD_DEPENDS = " \
    builtin-interfaces \
    clang \
    protobuf \
    rclcpp \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
    ament-cmake-python-native \
    rosidl-default-generators-native \
"

ROS_EXPORT_DEPENDS = " \
    builtin-interfaces \
    protobuf \
    rclcpp \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = " \
    ament-cmake-mypy-native \
    rosidl-default-generators-native \
"

ROS_EXEC_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-python3-inflection} \
    ${ROS_UNRESOLVED_DEP-python3-multipledispatch} \
    ${ROS_UNRESOLVED_DEP-python3-networkx} \
    builtin-interfaces \
    protobuf \
    python3-jinja2 \
    python3-numpy \
    python3-protobuf \
    python3-pyyaml \
    rclcpp \
    rclpy \
    rosidl-adapter \
    rosidl-default-runtime \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-pytest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/bdaiinstitute/proto2ros-release/archive/release/humble/proto2ros/1.0.0-3.tar.gz
ROS_BRANCH ?= "branch=release/humble/proto2ros"
SRC_URI = "git://github.com/bdaiinstitute/proto2ros-release;${ROS_BRANCH};protocol=https"
SRCREV = "15ea3f314010ea24ef8b8067c2c213140c46d31d"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

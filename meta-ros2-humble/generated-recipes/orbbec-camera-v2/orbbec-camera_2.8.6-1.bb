# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Orbbec Camera package"
AUTHOR = "yalian <yalian@orbbec.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "orbbec_camera_v2"
ROS_BPN = "orbbec_camera"

ROS_BUILD_DEPENDS = "\
    ament-index-cpp \
    ament-lint-auto \
    ament-lint-common \
    backward-ros \
    builtin-interfaces \
    camera-info-manager \
    cv-bridge \
    diagnostic-msgs \
    diagnostic-updater \
    gflags \
    glog \
    image-publisher \
    image-transport \
    mesa \
    nlohmann-json \
    openssl \
    orbbec-camera-msgs \
    rclcpp \
    rclcpp-components \
    sensor-msgs \
    statistics-msgs \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-msgs \
    tf2-ros \
    tf2-sensor-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    ament-index-cpp \
    ament-lint-auto \
    ament-lint-common \
    backward-ros \
    builtin-interfaces \
    camera-info-manager \
    cv-bridge \
    diagnostic-msgs \
    diagnostic-updater \
    gflags \
    glog \
    image-publisher \
    image-transport \
    mesa \
    nlohmann-json \
    openssl \
    orbbec-camera-msgs \
    rclcpp \
    rclcpp-components \
    sensor-msgs \
    statistics-msgs \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-msgs \
    tf2-ros \
    tf2-sensor-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    action-msgs \
    ament-cmake \
    ament-cmake-core \
    ament-cmake-export-definitions \
    ament-cmake-export-dependencies \
    ament-cmake-export-include-directories \
    ament-cmake-export-interfaces \
    ament-cmake-export-libraries \
    ament-cmake-export-link-flags \
    ament-cmake-export-targets \
    ament-cmake-gen-version-h \
    ament-cmake-libraries \
    ament-cmake-python \
    ament-cmake-target-dependencies \
    ament-cmake-test \
    ament-cmake-version \
    camera-calibration-parsers \
    class-loader \
    console-bridge \
    console-bridge-vendor \
    elfutils \
    gcc-runtime \
    geometry-msgs \
    libeigen \
    libstatistics-collector \
    libtinyxml2 \
    libyaml \
    libyaml-vendor \
    message-filters \
    opencv \
    pluginlib \
    python3-numpy \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-lifecycle \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp-action \
    rclpy \
    rcpputils \
    rcutils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-interface \
    tinyxml2-vendor \
    tracetools \
    unique-identifier-msgs \
    yaml-cpp \
    yaml-cpp-vendor \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-package-native \
    cmake-native \
    eigen3-cmake-module-native \
    python3-catkin-pkg-native \
    python3-importlib-metadata-native \
    python3-native \
    python3-setuptools-native \
"

ROS_EXEC_DEPENDS = "\
    ament-index-cpp \
    ament-lint-auto \
    ament-lint-common \
    backward-ros \
    builtin-interfaces \
    camera-info-manager \
    cv-bridge \
    diagnostic-msgs \
    diagnostic-updater \
    gflags \
    glog \
    image-publisher \
    image-transport \
    mesa \
    nlohmann-json \
    openssl \
    orbbec-camera-msgs \
    rclcpp \
    rclcpp-components \
    sensor-msgs \
    statistics-msgs \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-msgs \
    tf2-ros \
    tf2-sensor-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/orbbec_camera_v2-release/archive/release/humble/orbbec_camera/2.8.6-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/orbbec_camera"
SRC_URI = "git://github.com/ros2-gbp/orbbec_camera_v2-release;${ROS_BRANCH};protocol=https"
SRCREV = "2a16d261929b712d9e9e2aac853a9fad184689d3"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Orbbec Camera package"
AUTHOR = "yalian <yalian@orbbec.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "orbbec_camera_v2"
ROS_BPN = "orbbec_camera"

ROS_BUILD_DEPENDS = "\
    ament-index-cpp \
    ament-lint-auto \
    ament-lint-common \
    backward-ros \
    builtin-interfaces \
    camera-info-manager \
    cv-bridge \
    diagnostic-msgs \
    diagnostic-updater \
    geometry-msgs \
    gflags \
    glog \
    image-publisher \
    image-transport \
    libeigen \
    mesa \
    message-filters \
    nlohmann-json \
    opencv \
    openssl \
    orbbec-camera-msgs \
    pluginlib \
    rcl-interfaces \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rmw \
    sensor-msgs \
    statistics-msgs \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-msgs \
    tf2-ros \
    tf2-sensor-msgs \
    yaml-cpp \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    pkgconfig-native \
"

ROS_EXPORT_DEPENDS = "\
    ament-index-cpp \
    ament-lint-auto \
    ament-lint-common \
    backward-ros \
    builtin-interfaces \
    camera-info-manager \
    cv-bridge \
    diagnostic-msgs \
    diagnostic-updater \
    geometry-msgs \
    gflags \
    glog \
    image-publisher \
    image-transport \
    libeigen \
    mesa \
    message-filters \
    nlohmann-json \
    opencv \
    openssl \
    orbbec-camera-msgs \
    pluginlib \
    rcl-interfaces \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rmw \
    sensor-msgs \
    statistics-msgs \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-msgs \
    tf2-ros \
    tf2-sensor-msgs \
    yaml-cpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-index-cpp \
    ament-index-python \
    ament-lint-auto \
    ament-lint-common \
    backward-ros \
    builtin-interfaces \
    camera-info-manager \
    cv-bridge \
    diagnostic-msgs \
    diagnostic-updater \
    geometry-msgs \
    gflags \
    glog \
    image-publisher \
    image-transport \
    launch \
    launch-ros \
    libeigen \
    mesa \
    message-filters \
    nlohmann-json \
    opencv \
    openssl \
    orbbec-camera-msgs \
    pluginlib \
    python3-psutil \
    python3-pyyaml \
    python3-tabulate \
    rcl-interfaces \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rclpy \
    rmw \
    sensor-msgs \
    statistics-msgs \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-msgs \
    tf2-ros \
    tf2-sensor-msgs \
    yaml-cpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/orbbec_camera_v2-release/archive/release/humble/orbbec_camera/2.10.7-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/orbbec_camera"
SRC_URI = "git://github.com/ros2-gbp/orbbec_camera_v2-release;${ROS_BRANCH};protocol=https"
SRCREV = "b7aadfaf2b405fcf5d7cba7a4bf49284e01dde01"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

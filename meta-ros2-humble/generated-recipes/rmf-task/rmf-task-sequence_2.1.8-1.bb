# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Implementation of phase-sequence tasks for the Robotics Middleware Framework"
AUTHOR = "Grey <grey@openrobotics.org>"
ROS_AUTHOR = "Grey"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "rmf_task"
ROS_BPN = "rmf_task_sequence"

ROS_BUILD_DEPENDS = "\
    nlohmann-json \
    nlohmann-json-schema-validator-vendor \
    rmf-api-msgs \
    rmf-task \
"

ROS_BUILDTOOL_DEPENDS = "\
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    nlohmann-json \
    nlohmann-json-schema-validator-vendor \
    rmf-api-msgs \
    rmf-task \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    libccd \
    libeigen \
    python3-jinja2 \
    python3-jsonschema \
    rmf-battery \
    rmf-traffic \
    rmf-utils \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    eigen3-cmake-module-native \
"

ROS_EXEC_DEPENDS = "\
    nlohmann-json \
    nlohmann-json-schema-validator-vendor \
    rmf-api-msgs \
    rmf-task \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-catch2 \
    ament-cmake-uncrustify \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/rmf_task-release/archive/release/humble/rmf_task_sequence/2.1.8-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/rmf_task_sequence"
SRC_URI = "git://github.com/ros2-gbp/rmf_task-release;${ROS_BRANCH};protocol=https"
SRCREV = "95baffef1b1d8ffc93d4cfdd61c1df177bc4e8f0"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

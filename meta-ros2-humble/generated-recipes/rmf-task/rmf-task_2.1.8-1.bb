# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Package for managing tasks in the Robotics Middleware Framework"
AUTHOR = "Yadunund <yadunund@openrobotics.org>"
ROS_AUTHOR = "Aaron"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "rmf_task"
ROS_BPN = "rmf_task"

ROS_BUILD_DEPENDS = "\
    libeigen \
    rmf-battery \
    rmf-utils \
"

ROS_BUILDTOOL_DEPENDS = "\
    cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    libeigen \
    rmf-battery \
    rmf-utils \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    libccd \
    rmf-traffic \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    eigen3-cmake-module-native \
"

ROS_EXEC_DEPENDS = "\
    libeigen \
    rmf-battery \
    rmf-utils \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-catch2 \
    ament-cmake-uncrustify \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/rmf_task-release/archive/release/humble/rmf_task/2.1.8-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/rmf_task"
SRC_URI = "git://github.com/ros2-gbp/rmf_task-release;${ROS_BRANCH};protocol=https"
SRCREV = "b49b42823cbec02b769776ac817254f5fb1e672a"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

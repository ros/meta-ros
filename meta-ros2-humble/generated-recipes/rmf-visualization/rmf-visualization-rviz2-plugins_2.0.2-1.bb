# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "A package containing RViz2 plugins for RMF"
AUTHOR = "Yadunund <yadunund@openrobotics.org>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "rmf_visualization"
ROS_BPN = "rmf_visualization_rviz2_plugins"

ROS_BUILD_DEPENDS = "\
    libeigen \
    pluginlib \
    qtbase \
    rclcpp \
    resource-retriever \
    rmf-door-msgs \
    rmf-lift-msgs \
    rmf-traffic-ros2 \
    rmf-visualization-msgs \
    rviz-common \
    rviz-default-plugins \
    rviz-rendering \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    pluginlib \
    rclcpp \
    resource-retriever \
    rmf-door-msgs \
    rmf-lift-msgs \
    rmf-traffic-ros2 \
    rmf-visualization-msgs \
    rviz-common \
    rviz-default-plugins \
    rviz-rendering \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-ignition-cmake2} \
    ${ROS_UNRESOLVED_DEP-ignition-math6} \
    action-msgs \
    ament-cmake \
    ament-cmake-core \
    ament-cmake-export-definitions \
    ament-cmake-export-dependencies \
    ament-cmake-export-include-directories \
    ament-cmake-export-interfaces \
    ament-cmake-export-libraries \
    ament-cmake-export-link-flags \
    ament-cmake-export-targets \
    ament-cmake-gen-version-h \
    ament-cmake-libraries \
    ament-cmake-python \
    ament-cmake-target-dependencies \
    ament-cmake-test \
    ament-cmake-version \
    ament-index-cpp \
    ament-index-python \
    builtin-interfaces \
    class-loader \
    console-bridge \
    console-bridge-vendor \
    curl \
    eigen3-cmake-module \
    freetype \
    geometry-msgs \
    glew \
    ignition-cmake2-vendor \
    ignition-math6-vendor \
    image-transport \
    interactive-markers \
    laser-geometry \
    libccd \
    libcurl-vendor \
    libstatistics-collector \
    libtinyxml2 \
    libx11 \
    libxaw \
    libxrandr \
    libyaml \
    libyaml-vendor \
    map-msgs \
    mesa \
    message-filters \
    nav-msgs \
    nlohmann-json \
    orocos-kdl \
    orocos-kdl-vendor \
    proj \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp-action \
    rclcpp-components \
    rcpputils \
    rcutils \
    rmf-building-map-msgs \
    rmf-fleet-msgs \
    rmf-site-map-msgs \
    rmf-traffic \
    rmf-traffic-msgs \
    rmf-utils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-interface \
    rviz-ogre-vendor \
    sensor-msgs \
    statistics-msgs \
    std-msgs \
    tf2 \
    tf2-geometry-msgs \
    tf2-msgs \
    tf2-ros \
    tinyxml2-vendor \
    tracetools \
    unique-identifier-msgs \
    urdf \
    urdf-parser-plugin \
    urdfdom \
    urdfdom-headers \
    visualization-msgs \
    yaml-cpp \
    yaml-cpp-vendor \
    zlib \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-package-native \
    cmake-native \
    eigen3-cmake-module-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-importlib-metadata-native \
    python3-native \
    python3-setuptools-native \
"

ROS_EXEC_DEPENDS = "\
    pluginlib \
    qtbase \
    rclcpp \
    resource-retriever \
    rmf-door-msgs \
    rmf-lift-msgs \
    rmf-traffic-ros2 \
    rmf-visualization-msgs \
    rviz-common \
    rviz-default-plugins \
    rviz-rendering \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-uncrustify \
    rmf-utils \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/rmf_visualization-release/archive/release/humble/rmf_visualization_rviz2_plugins/2.0.2-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/rmf_visualization_rviz2_plugins"
SRC_URI = "git://github.com/ros2-gbp/rmf_visualization-release;${ROS_BRANCH};protocol=https"
SRCREV = "5bcdc0916fd3a74d36ae49c05b791f3b625e7832"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

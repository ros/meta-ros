# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "A C++ library offering a GTSAM ⇆ mrpt-serialization bridge."
AUTHOR = "Jose-Luis Blanco-Claraco <joseluisblancoc@gmail.com>"
HOMEPAGE = "https://github.com/MRPT/gtsam2mrpt_serial"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "gtsam2mrpt_serial"
ROS_BPN = "gtsam2mrpt_serial"

ROS_BUILD_DEPENDS = " \
    gtsam \
    mola-common \
    mrpt-libbase \
    mrpt-libmath \
    mrpt-libposes \
"

ROS_BUILDTOOL_DEPENDS = " \
    cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    gtsam \
    mola-common \
    mrpt-libbase \
    mrpt-libmath \
    mrpt-libposes \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    gtsam \
    mola-common \
    mrpt-libbase \
    mrpt-libmath \
    mrpt-libposes \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/gtsam2mrpt_serial-release/archive/release/humble/gtsam2mrpt_serial/0.2.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/gtsam2mrpt_serial"
SRC_URI = "git://github.com/ros2-gbp/gtsam2mrpt_serial-release;${ROS_BRANCH};protocol=https"
SRCREV = "cc3a2c9dfe9d74c7627486643c743f28170458ff"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

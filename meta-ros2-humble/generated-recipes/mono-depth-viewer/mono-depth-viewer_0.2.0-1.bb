# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Qt viewer that runs transformer-based monocular depth estimation on image topics stored in ROS 2 bags."
AUTHOR = "Divagar <n.divagar18@gmail.com>"
HOMEPAGE = "https://github.com/divagarn/mono_depth_ros2"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "mono_depth_viewer"
ROS_BPN = "mono_depth_viewer"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = ""

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    launch \
    launch-ros \
    opencv \
    python3-numpy \
    python3-pyqt5 \
    rclpy \
    sensor-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    python3-pytest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/divagarn/mono_depth_viewer-release/archive/release/humble/mono_depth_viewer/0.2.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/mono_depth_viewer"
SRC_URI = "git://github.com/divagarn/mono_depth_viewer-release;${ROS_BRANCH};protocol=https"
SRCREV = "d300ba1fe6bf387d8875bca4994fd75967c07dbe"

ROS_BUILD_TYPE = "ament_python"

inherit ros_${ROS_BUILD_TYPE}

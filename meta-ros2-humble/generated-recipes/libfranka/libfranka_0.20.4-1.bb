# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "libfranka is a C++ library for Franka Robotics research robots"
AUTHOR = "Franka Robotics GmbH <support@franka.de>"
ROS_AUTHOR = "Franka Robotics GmbH"
HOMEPAGE = "http://wiki.ros.org/libfranka"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "Apache 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=3dce4ba60d7e51ec64f3c3dc18672dd3"

ROS_CN = "libfranka"
ROS_BPN = "libfranka"

ROS_BUILD_DEPENDS = "\
    fmt \
    libeigen \
    libtinyxml2 \
    pinocchio \
    poco \
"

ROS_BUILDTOOL_DEPENDS = "\
    cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-liboctomap-dev} \
    assimp \
    boost \
    coal \
    eigenpy \
    python3 \
    python3-numpy \
    python3-scipy \
    ros-environment \
    urdfdom \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    fmt \
    libtinyxml2 \
    pinocchio \
    poco \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/frankaemika/libfranka-release/archive/release/humble/libfranka/0.20.4-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/libfranka"
SRC_URI = "git://github.com/frankaemika/libfranka-release;${ROS_BRANCH};protocol=https"
SRCREV = "419a3409e60b7150fbbdf095d1b65921ab971a28"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "CRANE+ V2 examples package"
AUTHOR = "RT Corporation <shop@rt-net.jp>"
ROS_AUTHOR = "Shota Aoki <s.aoki@rt-net.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "crane_plus"
ROS_BPN = "crane_plus_examples"

ROS_BUILD_DEPENDS = "\
    crane-plus-control \
    crane-plus-description \
    crane-plus-moveit-config \
    cv-bridge \
    geometry-msgs \
    image-geometry \
    moveit-ros-planning-interface \
    opencv \
    rclcpp \
    tf2-geometry-msgs \
    usb-cam \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    crane-plus-control \
    crane-plus-description \
    crane-plus-moveit-config \
    cv-bridge \
    geometry-msgs \
    image-geometry \
    moveit-ros-planning-interface \
    opencv \
    rclcpp \
    tf2-geometry-msgs \
    usb-cam \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-ignition-gazebo6} \
    ${ROS_UNRESOLVED_DEP-ignition-plugin} \
    ${ROS_UNRESOLVED_DEP-libexpected-dev} \
    ${ROS_UNRESOLVED_DEP-libgazebo11-dev} \
    action-msgs \
    ament-cmake \
    ament-cmake-core \
    ament-cmake-export-definitions \
    ament-cmake-export-dependencies \
    ament-cmake-export-include-directories \
    ament-cmake-export-interfaces \
    ament-cmake-export-libraries \
    ament-cmake-export-link-flags \
    ament-cmake-export-targets \
    ament-cmake-gen-version-h \
    ament-cmake-libraries \
    ament-cmake-python \
    ament-cmake-target-dependencies \
    ament-cmake-test \
    ament-cmake-version \
    ament-index-cpp \
    ament-index-python \
    angles \
    assimp \
    backward-ros \
    boost \
    builtin-interfaces \
    bullet \
    camera-calibration-parsers \
    camera-info-manager \
    class-loader \
    common-interfaces \
    console-bridge \
    console-bridge-vendor \
    control-msgs \
    control-toolbox \
    controller-interface \
    controller-manager \
    controller-manager-msgs \
    curl \
    dynamixel-sdk \
    eigen-stl-containers \
    eigen3-cmake-module \
    elfutils \
    fcl \
    ffmpeg \
    filters \
    fmt \
    freetype \
    gazebo-msgs \
    gazebo-ros \
    gazebo-ros2-control \
    gazebo-rosdev \
    generate-parameter-library \
    geometric-shapes \
    glew \
    gz-ros2-control \
    hardware-interface \
    ign-ros2-control \
    image-transport \
    image-transport-plugins \
    joint-state-publisher-gui \
    kdl-parser \
    launch \
    libcap \
    libcurl-vendor \
    libeigen \
    libstatistics-collector \
    libtinyxml \
    libtinyxml2 \
    libx11 \
    libxaw \
    libxrandr \
    libyaml \
    libyaml-vendor \
    lifecycle-msgs \
    mesa \
    message-filters \
    moveit \
    moveit-common \
    moveit-core \
    moveit-msgs \
    moveit-ros-move-group \
    moveit-ros-occupancy-map-monitor \
    moveit-ros-planning \
    moveit-ros-warehouse \
    object-recognition-msgs \
    octomap \
    octomap-msgs \
    opencv \
    openssl \
    orocos-kdl \
    orocos-kdl-vendor \
    osrf-pycommon \
    parameter-traits \
    pluginlib \
    pybind11-vendor \
    python3 \
    python3-numpy \
    python3-pybind11 \
    python3-pyyaml \
    qtbase \
    random-numbers \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-lifecycle \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp-action \
    rclcpp-components \
    rclcpp-lifecycle \
    rclpy \
    rcpputils \
    rcutils \
    realtime-tools \
    resource-retriever \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    robot-state-publisher \
    ros2-controllers \
    ros2cli \
    ros2controlcli \
    ros2node \
    ros2param \
    rosgraph-msgs \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-interface \
    rsl \
    ruckig \
    rviz-common \
    rviz-ogre-vendor \
    rviz-rendering \
    rviz2 \
    sensor-msgs \
    shape-msgs \
    srdfdom \
    statistics-msgs \
    std-msgs \
    std-srvs \
    tcb-span \
    tf2 \
    tf2-eigen \
    tf2-kdl \
    tf2-msgs \
    tf2-ros \
    tinyxml-vendor \
    tinyxml2-vendor \
    tl-expected \
    tracetools \
    trajectory-msgs \
    unique-identifier-msgs \
    urdf \
    urdf-parser-plugin \
    urdfdom \
    urdfdom-headers \
    v4l-utils \
    visualization-msgs \
    warehouse-ros \
    xacro \
    yaml-cpp \
    yaml-cpp-vendor \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-package-native \
    cmake-native \
    eigen3-cmake-module-native \
    generate-parameter-library-py-native \
    pkgconfig-native \
    python3-catkin-pkg-native \
    python3-importlib-metadata-native \
    python3-jinja2-native \
    python3-native \
    python3-pyyaml-native \
    python3-setuptools-native \
    python3-typeguard-native \
"

ROS_EXEC_DEPENDS = "\
    crane-plus-control \
    crane-plus-description \
    crane-plus-moveit-config \
    cv-bridge \
    geometry-msgs \
    image-geometry \
    moveit-ros-planning-interface \
    opencv \
    rclcpp \
    tf2-geometry-msgs \
    usb-cam \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/crane_plus-release/archive/release/humble/crane_plus_examples/2.0.1-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/crane_plus_examples"
SRC_URI = "git://github.com/ros2-gbp/crane_plus-release;${ROS_BRANCH};protocol=https"
SRCREV = "48a0fbcbb12a3db610c7dc1179adfc296a5b23b8"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Broadcaster to publish robot states"
AUTHOR = "Franka Robotics GmbH <support@franka.de>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "Apache 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=3dce4ba60d7e51ec64f3c3dc18672dd3"

ROS_CN = "franka_ros2"
ROS_BPN = "franka_robot_state_broadcaster"

ROS_BUILD_DEPENDS = "\
    backward-ros \
    builtin-interfaces \
    control-msgs \
    controller-interface \
    franka-msgs \
    franka-semantic-components \
    generate-parameter-library \
    pluginlib \
    rclcpp-lifecycle \
    rcutils \
    realtime-tools \
    sensor-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    backward-ros \
    builtin-interfaces \
    control-msgs \
    controller-interface \
    franka-msgs \
    franka-semantic-components \
    generate-parameter-library \
    pluginlib \
    rclcpp-lifecycle \
    rcutils \
    realtime-tools \
    sensor-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

# Propagated from the <build_export_depend>/<buildtool_export_depend> tags of the
# packages above, transitively. Bitbake has no "export" concept, so superflore
# flattens REP-149 export semantics into this recipe.
ROS_TRANSITIVE_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libexpected-dev} \
    action-msgs \
    ament-cmake \
    ament-cmake-core \
    ament-cmake-export-definitions \
    ament-cmake-export-dependencies \
    ament-cmake-export-include-directories \
    ament-cmake-export-interfaces \
    ament-cmake-export-libraries \
    ament-cmake-export-link-flags \
    ament-cmake-export-targets \
    ament-cmake-gen-version-h \
    ament-cmake-libraries \
    ament-cmake-python \
    ament-cmake-target-dependencies \
    ament-cmake-test \
    ament-cmake-version \
    ament-index-cpp \
    boost \
    class-loader \
    elfutils \
    fmt \
    franka-hardware \
    geometry-msgs \
    hardware-interface \
    libcap \
    libeigen \
    libfranka \
    libstatistics-collector \
    libtinyxml2 \
    libyaml \
    libyaml-vendor \
    lifecycle-msgs \
    parameter-traits \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-lifecycle \
    rcl-logging-interface \
    rcl-logging-spdlog \
    rcl-yaml-param-parser \
    rclcpp \
    rclcpp-action \
    rclpy \
    rcpputils \
    rmw \
    rmw-implementation \
    rmw-implementation-cmake \
    rosgraph-msgs \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-interface \
    rsl \
    statistics-msgs \
    std-msgs \
    tcb-span \
    tinyxml2-vendor \
    tl-expected \
    tracetools \
    trajectory-msgs \
    unique-identifier-msgs \
"

ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS = "\
    ament-cmake-core-native \
    ament-cmake-export-definitions-native \
    ament-cmake-export-dependencies-native \
    ament-cmake-export-include-directories-native \
    ament-cmake-export-interfaces-native \
    ament-cmake-export-libraries-native \
    ament-cmake-export-link-flags-native \
    ament-cmake-export-targets-native \
    ament-cmake-gen-version-h-native \
    ament-cmake-include-directories-native \
    ament-cmake-libraries-native \
    ament-cmake-python-native \
    ament-cmake-target-dependencies-native \
    ament-cmake-test-native \
    ament-cmake-version-native \
    ament-package-native \
    cmake-native \
    generate-parameter-library-py-native \
    python3-catkin-pkg-native \
    python3-importlib-metadata-native \
    python3-jinja2-native \
    python3-native \
    python3-pyyaml-native \
    python3-setuptools-native \
    python3-typeguard-native \
"

ROS_EXEC_DEPENDS = "\
    backward-ros \
    builtin-interfaces \
    control-msgs \
    controller-interface \
    franka-msgs \
    franka-semantic-components \
    generate-parameter-library \
    pluginlib \
    rclcpp-lifecycle \
    rcutils \
    realtime-tools \
    sensor-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gmock \
    controller-manager \
    hardware-interface \
    rclcpp \
    ros2-control-test-assets \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"
DEPENDS += "${ROS_TRANSITIVE_EXPORT_DEPENDS} ${ROS_TRANSITIVE_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/franka_ros2-release/archive/release/humble/franka_robot_state_broadcaster/1.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/franka_robot_state_broadcaster"
SRC_URI = "git://github.com/ros2-gbp/franka_ros2-release;${ROS_BRANCH};protocol=https"
SRCREV = "3e0dc9752932d90883e834e952f365ef3efc57ab"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

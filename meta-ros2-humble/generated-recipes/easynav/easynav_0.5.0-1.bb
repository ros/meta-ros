# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Easy Navigation:Mata package for installing all EasyNav."
AUTHOR = "Francisco Martín Rico <fmrico@gmail.com>"
ROS_AUTHOR = "Francisco Martín Rico"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "easynav"
ROS_BPN = "easynav"

ROS_BUILD_DEPENDS = "\
    easynav-common \
    easynav-controller \
    easynav-core \
    easynav-interfaces \
    easynav-localizer \
    easynav-maps-manager \
    easynav-planner \
    easynav-recovery \
    easynav-sensors \
    easynav-system \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    easynav-common \
    easynav-controller \
    easynav-core \
    easynav-interfaces \
    easynav-localizer \
    easynav-maps-manager \
    easynav-planner \
    easynav-recovery \
    easynav-sensors \
    easynav-system \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    easynav-common \
    easynav-controller \
    easynav-core \
    easynav-interfaces \
    easynav-localizer \
    easynav-maps-manager \
    easynav-planner \
    easynav-recovery \
    easynav-sensors \
    easynav-support-py \
    easynav-system \
    easynav-tools \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/EasyNavigation/EasyNavigation-release/archive/release/humble/easynav/0.5.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/easynav"
SRC_URI = "git://github.com/EasyNavigation/EasyNavigation-release;${ROS_BRANCH};protocol=https"
SRCREV = "ab414ec509e61f24cf154ea806b2f6f7a8be9fc5"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "ROS 2 Navigation tools: TUI + ros2cli commands for EasyNav."
AUTHOR = "Francisco Martín Rico <fmrico@gmail.com>"
ROS_AUTHOR = "Francisco Martín Rico"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "easynav"
ROS_BPN = "easynav_tools"

ROS_BUILD_DEPENDS = "\
    diagnostic-msgs \
    geometry-msgs \
    rcl-interfaces \
    rclpy \
    rosidl-runtime-py \
"

ROS_BUILDTOOL_DEPENDS = ""

ROS_EXPORT_DEPENDS = "\
    diagnostic-msgs \
    geometry-msgs \
    rcl-interfaces \
    rclpy \
    rosidl-runtime-py \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-index-python \
    diagnostic-msgs \
    easynav-interfaces \
    easynav-support-py \
    geometry-msgs \
    python3-platformdirs \
    python3-rich \
    python3-typing-extensions \
    rcl-interfaces \
    rclpy \
    ros2cli \
    rosidl-runtime-py \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-pytest \
    ament-copyright \
    ament-flake8 \
    ament-pep257 \
    ament-xmllint \
    builtin-interfaces \
    nav-msgs \
    python3-pytest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/EasyNavigation/EasyNavigation-release/archive/release/humble/easynav_tools/0.5.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/easynav_tools"
SRC_URI = "git://github.com/EasyNavigation/EasyNavigation-release;${ROS_BRANCH};protocol=https"
SRCREV = "d1cb09310954a4c93100782ff3532fd41c41384a"

ROS_BUILD_TYPE = "ament_python"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "The tiago_dual_gazebo package"
AUTHOR = "David ter Kuile <david.terkuile@pal-robotics.com>"
ROS_AUTHOR = "David ter Kuile <david.terkuile@pal-robotics.com>"
HOMEPAGE = "https://github.com/pal-robotics/tiago_dual_simulation"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "tiago_dual_simulation"
ROS_BPN = "tiago_dual_gazebo"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-gz-sensors6} \
    gazebo-plugins \
    gazebo-ros \
    gazebo-ros2-control \
    gz-ros2-control \
    launch \
    launch-pal \
    launch-ros \
    pal-gazebo-plugins \
    pal-gazebo-worlds \
    pal-maps \
    pal-urdf-utils \
    play-motion2-msgs \
    ros-gz-bridge \
    tiago-dual-2dnav \
    tiago-dual-bringup \
    tiago-dual-description \
    tiago-dual-laser-sensors \
    tiago-dual-moveit-config \
    tiago-dual-rgbd-sensors \
    tiago-gazebo \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
    launch-testing-ament-cmake \
    play-motion2-msgs \
    rclcpp \
    sensor-msgs \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/tiago_dual_simulation-release/archive/release/humble/tiago_dual_gazebo/4.14.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/tiago_dual_gazebo"
SRC_URI = "git://github.com/ros2-gbp/tiago_dual_simulation-release;${ROS_BRANCH};protocol=https"
SRCREV = "283d5f2f5f7511da8d2fa6d7f0fbd08cbaa197c7"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

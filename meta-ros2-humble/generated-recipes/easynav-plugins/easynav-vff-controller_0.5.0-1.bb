# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "Easy Navigation: VFF Controller package."
AUTHOR = "Jose Miguel Guerrero Hernandez <josemiguel.guerrero@urjc.es>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "easynav_plugins"
ROS_BPN = "easynav_vff_controller"

ROS_BUILD_DEPENDS = "\
    easynav-common \
    easynav-core \
    easynav-sensors \
    geometry-msgs \
    nav-msgs \
    pcl \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    tf2 \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    easynav-common \
    easynav-core \
    easynav-sensors \
    geometry-msgs \
    nav-msgs \
    pcl \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    tf2 \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    easynav-common \
    easynav-core \
    easynav-sensors \
    geometry-msgs \
    nav-msgs \
    pcl \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    tf2 \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-lint-auto \
    ament-lint-common \
    easynav-controller \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/EasyNavigation/easynav_plugins-release/archive/release/humble/easynav_vff_controller/0.5.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/easynav_vff_controller"
SRC_URI = "git://github.com/EasyNavigation/easynav_plugins-release;${ROS_BRANCH};protocol=https"
SRCREV = "c80452e7b4a3bc3e6d79eaf7f54208fa96a33717"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

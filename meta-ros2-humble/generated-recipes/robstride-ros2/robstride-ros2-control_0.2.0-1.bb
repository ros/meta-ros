# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_humble
inherit ros_superflore_generated

DESCRIPTION = "ros2_control SystemInterface for multi-axis RobStride private-CAN actuators."
AUTHOR = "yamato <ykturtler@outlook.com>"
HOMEPAGE = "https://github.com/s2015-turtle/robstride_ros2"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "robstride_ros2"
ROS_BPN = "robstride_ros2_control"

ROS_BUILD_DEPENDS = "\
    hardware-interface \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    robstride-driver \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    hardware-interface \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    robstride-driver \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    hardware-interface \
    pluginlib \
    rclcpp \
    rclcpp-lifecycle \
    robstride-driver \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/robstride_ros2-release/archive/release/humble/robstride_ros2_control/0.2.0-1.tar.gz
ROS_BRANCH ?= "branch=release/humble/robstride_ros2_control"
SRC_URI = "git://github.com/ros2-gbp/robstride_ros2-release;${ROS_BRANCH};protocol=https"
SRCREV = "ea62adcc18631526025fd7d8085cd9dc91927baa"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Copyright (c) 2021 LG Electronics, Inc.

# Depends on webots-ros2-driver with this restriction
COMPATIBLE_MACHINE = "(^$)"
COMPATIBLE_MACHINE:x86-64 = "(.*)"

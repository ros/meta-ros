# ERROR: tl-expected-1.0.2-5-r0 do_create_spdx: Cannot find any text for license Creative-Commons-Zero-v1.0-Universal
# Convert Creative-Commons-Zero-v1.0-Universal to SPDX identifier CC0-1.0
LICENSE = "CC0-1.0"

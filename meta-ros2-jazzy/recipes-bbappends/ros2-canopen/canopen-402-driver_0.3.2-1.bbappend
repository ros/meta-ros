LICENSE = "LGPL-3.0-only"

CXXFLAGS += "-Wno-error=format-security"

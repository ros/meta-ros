CXXFLAGS += "-Wno-error=deprecated-declarations -Wno-error=maybe-uninitialized -Wno-error=format-security -Wno-error=unused-parameter"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-Install-libmotion_generator-to-standard-lib-dir.patch"

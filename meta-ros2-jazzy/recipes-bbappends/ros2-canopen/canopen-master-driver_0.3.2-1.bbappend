CXXFLAGS += "-Wno-error=format-security"

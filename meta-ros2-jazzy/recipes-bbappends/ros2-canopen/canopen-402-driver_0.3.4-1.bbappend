# Copyright (c) 2026 Wind River Systems, Inc.

LICENSE = "LGPL-3.0-only"

# Copyright (c) 2023 Wind River Systems, Inc.

LICENSE = "BSD-3-Clause"

ROS_BUILDTOOL_DEPENDS += " \
    rosidl-default-generators-native \
"

ROS_BUILD_DEPENDS += " \
    service-msgs \
"

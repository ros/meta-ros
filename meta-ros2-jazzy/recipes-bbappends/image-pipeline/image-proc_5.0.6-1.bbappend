# Copyright (c) 2025 Wind River Systems, Inc.

FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://new-api-for-opencv-aruco.patch"

LICENSE = "BSD-3-Clause"

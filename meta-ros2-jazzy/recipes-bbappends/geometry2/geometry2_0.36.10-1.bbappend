# Copyright (c) 2023 Wind River Systems, Inc.

LICENSE = "BSD-3-Clause"

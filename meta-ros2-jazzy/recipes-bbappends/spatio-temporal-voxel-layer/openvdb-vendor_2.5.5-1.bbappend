# Copyright (c) 2026 Wind River Systems, Inc.

LICENSE = "LGPL-2.1-only & MPL-2.0"

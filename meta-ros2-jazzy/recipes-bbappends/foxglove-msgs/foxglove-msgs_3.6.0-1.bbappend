# Copyright (c) 2023 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += " \
    service-msgs \
"

ROS_BUILDTOOL_DEPENDS += " \
    rosidl-default-generators-native \
    ros-environment-native \
"

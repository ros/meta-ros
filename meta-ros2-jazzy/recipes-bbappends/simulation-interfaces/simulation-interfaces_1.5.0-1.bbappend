# Copyright (c) 2026 Wind River Systems, Inc.

ROS_BUILD_DEPENDS += "\
    action-msgs \
"

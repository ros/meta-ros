# Copyright (c) 2026 Wind River Systems, Inc.

# CMake Error at generate_parameter_library.cmake:34 (message):
#   generate_parameter_library_cpp() variable
#   'generate_parameter_library_cpp_BIN' must not be empty
ROS_BUILDTOOL_DEPENDS += "generate-parameter-library-py-native"

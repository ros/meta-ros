# Copyright (c) 2023 Wind River Systems, Inc.

LICENSE = "Apache-2.0"

inherit pkgconfig

# Copyright (c) 2026 Wind River Systems, Inc.

LICENSE = "BSD-3-Clause AND MIT AND MIT AND WTFPL AND Zlib AND Apache-2.0"

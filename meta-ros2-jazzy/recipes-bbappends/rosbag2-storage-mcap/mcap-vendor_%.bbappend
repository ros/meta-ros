# Copyright (c) 2022 Wind River Systems, Inc.

EXTRA_OECMAKE:append = " -DFETCHCONTENT_FULLY_DISCONNECTED=OFF"

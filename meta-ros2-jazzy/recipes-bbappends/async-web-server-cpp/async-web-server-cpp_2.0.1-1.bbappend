# Copyright (c) 2021 LG Electronics, Inc.

# ERROR: async-web-server-cpp-2.0.0-1-r0 do_package_qa: QA Issue:
# non -dev/-dbg/nativesdk- package contains symlink .so: async-web-server-cpp path '/work/raspberrypi4-webos-linux-gnueabi/async-web-server-cpp/2.0.0-1-r0/packages-split/async-web-server-cpp/usr/lib/libasync_web_server_cpp.so' [dev-so]
inherit ros_insane_dev_so

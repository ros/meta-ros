# Copyright (c) 2026 Wind River Systems, Inc.

LICENSE = "MIT AND BSD-3-Clause"

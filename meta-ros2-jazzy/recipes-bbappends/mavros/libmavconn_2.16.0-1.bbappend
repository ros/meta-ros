# Copyright (c) 2021 LG Electronics, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    python3-empy-native \
"

LICENSE = "GPL-3.0-only AND LGPL-3.0-only AND BSD-3-Clause"

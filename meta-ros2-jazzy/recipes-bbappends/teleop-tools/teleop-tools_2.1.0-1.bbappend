# Copyright (c) 2026 Wind River Systems, Inc.

# package.xml declares "BSD" but the package has no license text. Other
# packages in the same upstream repository carry BSD-3-Clause headers.
LICENSE = "BSD-3-Clause"

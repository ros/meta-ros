do_compile[network]="1"

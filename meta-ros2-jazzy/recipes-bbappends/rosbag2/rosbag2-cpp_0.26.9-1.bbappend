# Copyright (c) 2020 LG Electronics, Inc.

ROS_BUILD_DEPENDS += "rosidl-cmake"

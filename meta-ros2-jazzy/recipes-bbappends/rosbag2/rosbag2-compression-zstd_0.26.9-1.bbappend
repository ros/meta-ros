# Copyright (c) 2020 LG Electronics, Inc.

inherit pkgconfig

# Copyright (c) 2023 Wind River Systems, Inc.

LICENSE = "BSD-3-Clause"

FILES:${PN}-dev += "${libdir}/liblanelet2_io.so"

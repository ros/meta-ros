LICENSE = "Apache-2.0"

ROS_BUILDTOOL_DEPENDS += " \
    rosidl-generator-c-native \
    rosidl-generator-cpp-native \
    fastrtps-cmake-module-native \
"

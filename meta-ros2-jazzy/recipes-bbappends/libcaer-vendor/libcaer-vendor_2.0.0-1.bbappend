# Copyright (c) 2026 Wind River Systems, Inc.

LICENSE = "Apache-2.0 & BSD-2-Clause"

FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0001-Fix-compilation-issue-due-to-missing-define.patch"

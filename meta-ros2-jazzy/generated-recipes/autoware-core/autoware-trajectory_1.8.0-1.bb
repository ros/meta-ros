# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "The autoware_trajectory package"
AUTHOR = "Yukinari Hisaki <yukinari.hisaki.2@tier4.jp>"
ROS_AUTHOR = "Yukinari Hisaki <yukinari.hisaki.2@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=16;endline=16;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_core"
ROS_BPN = "autoware_trajectory"

ROS_BUILD_DEPENDS = " \
    autoware-internal-planning-msgs \
    autoware-lanelet2-utils \
    autoware-planning-msgs \
    autoware-utils-geometry \
    fmt \
    geometry-msgs \
    lanelet2-core \
    rclcpp \
    tf2 \
    tf2-geometry-msgs \
    tl-expected \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-auto-native \
    autoware-cmake-native \
    python-cmake-module-native \
"

ROS_EXPORT_DEPENDS = " \
    autoware-internal-planning-msgs \
    autoware-lanelet2-utils \
    autoware-planning-msgs \
    autoware-utils-geometry \
    fmt \
    geometry-msgs \
    lanelet2-core \
    rclcpp \
    tf2 \
    tf2-geometry-msgs \
    tl-expected \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    autoware-internal-planning-msgs \
    autoware-lanelet2-utils \
    autoware-planning-msgs \
    autoware-utils-geometry \
    fmt \
    geometry-msgs \
    lanelet2-core \
    rclcpp \
    tf2 \
    tf2-geometry-msgs \
    tl-expected \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-auto \
    ament-index-cpp \
    autoware-lint-common \
    autoware-motion-utils \
    autoware-pyplot \
    autoware-test-utils \
    autoware-utils-geometry \
    pybind11-vendor \
    python3 \
    python3-matplotlib \
    range-v3 \
    yaml-cpp \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/autoware_core-release/archive/release/jazzy/autoware_trajectory/1.8.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/autoware_trajectory"
SRC_URI = "git://github.com/ros2-gbp/autoware_core-release;${ROS_BRANCH};protocol=https"
SRCREV = "b1274e4a82c53ee0f3c05b6c092dd9084d1d327f"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "obstacle stop feature in motion_velocity_planner"
AUTHOR = "Takayuki Murooka <takayuki.murooka@tier4.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=15;endline=15;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "autoware_core"
ROS_BPN = "autoware_motion_velocity_obstacle_stop_module"

ROS_BUILD_DEPENDS = " \
    autoware-internal-planning-msgs \
    autoware-motion-utils \
    autoware-motion-velocity-planner-common \
    autoware-perception-msgs \
    autoware-planning-msgs \
    autoware-signal-processing \
    autoware-utils-debug \
    autoware-utils-geometry \
    autoware-utils-rclcpp \
    autoware-utils-system \
    autoware-utils-uuid \
    autoware-utils-visualization \
    autoware-vehicle-info-utils \
    boost \
    geometry-msgs \
    grid-map-core \
    pluginlib \
    rclcpp \
    tf2 \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-auto-native \
    autoware-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    autoware-internal-planning-msgs \
    autoware-motion-utils \
    autoware-motion-velocity-planner-common \
    autoware-perception-msgs \
    autoware-planning-msgs \
    autoware-signal-processing \
    autoware-utils-debug \
    autoware-utils-geometry \
    autoware-utils-rclcpp \
    autoware-utils-system \
    autoware-utils-uuid \
    autoware-utils-visualization \
    autoware-vehicle-info-utils \
    boost \
    geometry-msgs \
    grid-map-core \
    pluginlib \
    rclcpp \
    tf2 \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    autoware-internal-planning-msgs \
    autoware-motion-utils \
    autoware-motion-velocity-planner-common \
    autoware-perception-msgs \
    autoware-planning-msgs \
    autoware-signal-processing \
    autoware-utils-debug \
    autoware-utils-geometry \
    autoware-utils-rclcpp \
    autoware-utils-system \
    autoware-utils-uuid \
    autoware-utils-visualization \
    autoware-vehicle-info-utils \
    boost \
    geometry-msgs \
    grid-map-core \
    pluginlib \
    rclcpp \
    tf2 \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-gtest \
    ament-cmake-ros \
    ament-lint-auto \
    autoware-lint-common \
    autoware-test-utils \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/autoware_core-release/archive/release/jazzy/autoware_motion_velocity_obstacle_stop_module/1.8.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/autoware_motion_velocity_obstacle_stop_module"
SRC_URI = "git://github.com/ros2-gbp/autoware_core-release;${ROS_BRANCH};protocol=https"
SRCREV = "9477f3a0d64655e190a278fac1b0ee11abce79e5"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

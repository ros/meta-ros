# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "map and poi server"
AUTHOR = "Shunsuke Kimura <kimura.shunsuke@shimz.co.jp>"
ROS_AUTHOR = "Shunsuke Kimura <kimura.shunsuke@shimz.co.jp>"
HOMEPAGE = "https://github.com/shimz-robotics/mapoi"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "mapoi"
ROS_BPN = "mapoi_server"

ROS_BUILD_DEPENDS = "\
    ament-cmake-auto \
    ament-index-cpp \
    geometry-msgs \
    mapoi-interfaces \
    nav2-msgs \
    rclcpp \
    rclcpp-action \
    ros-gz-interfaces \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
    visualization-msgs \
    yaml-cpp-vendor \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    ament-cmake-auto \
    ament-index-cpp \
    geometry-msgs \
    mapoi-interfaces \
    nav2-msgs \
    rclcpp \
    rclcpp-action \
    ros-gz-interfaces \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
    visualization-msgs \
    yaml-cpp-vendor \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-cmake-auto \
    ament-index-cpp \
    geometry-msgs \
    mapoi-interfaces \
    nav2-msgs \
    rclcpp \
    rclcpp-action \
    ros-gz-bridge \
    ros-gz-interfaces \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
    visualization-msgs \
    yaml-cpp-vendor \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-cmake-pytest \
    ament-lint-auto \
    ament-lint-common \
    launch-testing \
    launch-testing-ament-cmake \
    launch-testing-ros \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/shimz-robotics/mapoi-release/archive/release/jazzy/mapoi_server/0.6.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/mapoi_server"
SRC_URI = "git://github.com/shimz-robotics/mapoi-release;${ROS_BRANCH};protocol=https"
SRCREV = "d9fbf47ecb2fca9db499dfac314ecaad18936645"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Rviz2 plugins for mapoi"
AUTHOR = "Shunsuke Kimura <kimura.shunsuke@shimz.co.jp>"
ROS_AUTHOR = "Shunsuke Kimura <kimura.shunsuke@shimz.co.jp>"
HOMEPAGE = "https://github.com/shimz-robotics/mapoi"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "mapoi"
ROS_BPN = "mapoi_rviz_plugins"

ROS_BUILD_DEPENDS = "\
    ament-cmake-auto \
    geometry-msgs \
    mapoi-interfaces \
    rviz-common \
    rviz-default-plugins \
    std-srvs \
    tf2 \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    ament-cmake-auto \
    geometry-msgs \
    mapoi-interfaces \
    rviz-common \
    rviz-default-plugins \
    std-srvs \
    tf2 \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-cmake-auto \
    geometry-msgs \
    mapoi-interfaces \
    rviz-common \
    rviz-default-plugins \
    std-srvs \
    tf2 \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/shimz-robotics/mapoi-release/archive/release/jazzy/mapoi_rviz_plugins/0.6.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/mapoi_rviz_plugins"
SRC_URI = "git://github.com/shimz-robotics/mapoi-release;${ROS_BRANCH};protocol=https"
SRCREV = "c8b389ab025f2b1cebee34b49ea53a41cf5751f7"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

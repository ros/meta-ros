# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "msg and srv files used by mapoi packages"
AUTHOR = "Shunsuke Kimura <kimura.shunsuke@shimz.co.jp>"
ROS_AUTHOR = "Shunsuke Kimura <kimura.shunsuke@shimz.co.jp>"
HOMEPAGE = "https://github.com/shimz-robotics/mapoi"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "mapoi"
ROS_BPN = "mapoi_interfaces"

ROS_BUILD_DEPENDS = "\
    builtin-interfaces \
    geometry-msgs \
    rosidl-default-generators \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    builtin-interfaces \
    geometry-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    builtin-interfaces \
    geometry-msgs \
    rosidl-default-runtime \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/shimz-robotics/mapoi-release/archive/release/jazzy/mapoi_interfaces/0.6.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/mapoi_interfaces"
SRC_URI = "git://github.com/shimz-robotics/mapoi-release;${ROS_BRANCH};protocol=https"
SRCREV = "863d67b3e7623f5f82caed4728849ca5a23e0f8e"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

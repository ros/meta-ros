# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Message contract for the ProxMPC stack: Obstacle and ObstacleArray   carry tracked-obstacle id, position, velocity, radius, covariances, and sampled   predicted positions from the obstacle tracker to the Nav2 controller plugin;   SolverDiagnostics carries per-control-cycle NMPC/QP solver telemetry.   Interface-only package; no node."
AUTHOR = "Simone Contorno <simone.contorno@outlook.it>"
HOMEPAGE = "https://github.com/simone-contorno/prox_mpc"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "prox_mpc"
ROS_BPN = "prox_mpc_msgs"

ROS_BUILD_DEPENDS = "\
    geometry-msgs \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    rosidl-default-generators-native \
"

ROS_EXPORT_DEPENDS = "\
    geometry-msgs \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    geometry-msgs \
    rosidl-default-runtime \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/simone-contorno/prox_mpc-release/archive/release/jazzy/prox_mpc_msgs/1.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/prox_mpc_msgs"
SRC_URI = "git://github.com/simone-contorno/prox_mpc-release;${ROS_BRANCH};protocol=https"
SRCREV = "59353b53bb204c0c15d432d64fd1e337c7543931"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

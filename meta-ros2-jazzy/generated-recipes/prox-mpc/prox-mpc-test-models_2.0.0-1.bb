# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Test-fixture prox_mpc::Model plugins for the ProxMPC stack. These   models exercise controller paths the bundled production models cannot reach   (for example a non-finite command, or an asymmetric bound). Not for   production use. Fixture class names are not a stable interface and may   change without notice."
AUTHOR = "Simone Contorno <simone.contorno@outlook.it>"
ROS_AUTHOR = "Simone Contorno <simone.contorno@outlook.it>"
HOMEPAGE = "https://github.com/simone-contorno/prox_mpc"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "prox_mpc"
ROS_BPN = "prox_mpc_test_models"

ROS_BUILD_DEPENDS = "\
    geometry-msgs \
    libeigen \
    pluginlib \
    prox-mpc-core \
    proxsuite \
    rclcpp \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    geometry-msgs \
    libeigen \
    pluginlib \
    prox-mpc-core \
    proxsuite \
    rclcpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    geometry-msgs \
    libeigen \
    pluginlib \
    prox-mpc-core \
    proxsuite \
    rclcpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/simone-contorno/prox_mpc-release/archive/release/jazzy/prox_mpc_test_models/2.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/prox_mpc_test_models"
SRC_URI = "git://github.com/simone-contorno/prox_mpc-release;${ROS_BRANCH};protocol=https"
SRCREV = "de88d904366a3b0dca59f4d8130f3fa9aa5d36a3"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

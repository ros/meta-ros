# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Nav2 nav2_core::Controller plugin built on the ProxMPC core: it   builds the reference from the global plan, reduces the local costmap (and,   optionally, tracked dynamic obstacles) to the solver's constraints, solves one   SQP cycle per control step, and decelerates safely on a failed solve. Verified   in simulation under a full Nav2 stack."
AUTHOR = "Simone Contorno <simone.contorno@outlook.it>"
HOMEPAGE = "https://github.com/simone-contorno/prox_mpc"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "prox_mpc"
ROS_BPN = "prox_mpc_controller"

ROS_BUILD_DEPENDS = "\
    geometry-msgs \
    libeigen \
    nav-msgs \
    nav2-core \
    nav2-costmap-2d \
    nav2-util \
    pluginlib \
    prox-mpc-core \
    prox-mpc-msgs \
    proxsuite \
    rclcpp \
    rclcpp-lifecycle \
    tf2 \
    tf2-ros \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    geometry-msgs \
    libeigen \
    nav-msgs \
    nav2-core \
    nav2-costmap-2d \
    nav2-util \
    pluginlib \
    prox-mpc-core \
    prox-mpc-msgs \
    proxsuite \
    rclcpp \
    rclcpp-lifecycle \
    tf2 \
    tf2-ros \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    geometry-msgs \
    libeigen \
    nav-msgs \
    nav2-core \
    nav2-costmap-2d \
    nav2-util \
    pluginlib \
    prox-mpc-core \
    prox-mpc-msgs \
    proxsuite \
    rclcpp \
    rclcpp-lifecycle \
    tf2 \
    tf2-ros \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-lint-auto \
    ament-lint-common \
    prox-mpc-test-models \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/simone-contorno/prox_mpc-release/archive/release/jazzy/prox_mpc_controller/1.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/prox_mpc_controller"
SRC_URI = "git://github.com/simone-contorno/prox_mpc-release;${ROS_BRANCH};protocol=https"
SRCREV = "ef6096e0851c1f87d57e7b288ada51d1497e05ee"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Integration tests and demo nodes for ros2_medkit"
AUTHOR = "bburda <bartoszburda93@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "ros2_medkit"
ROS_BPN = "ros2_medkit_integration_tests"

ROS_BUILD_DEPENDS = " \
    diagnostic-msgs \
    example-interfaces \
    rcl-interfaces \
    rclcpp \
    rclcpp-action \
    ros2-medkit-msgs \
    sensor-msgs \
    std-msgs \
    std-srvs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
    ament-cmake-python-native \
    ros2-medkit-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    diagnostic-msgs \
    example-interfaces \
    rcl-interfaces \
    rclcpp \
    rclcpp-action \
    ros2-medkit-msgs \
    sensor-msgs \
    std-msgs \
    std-srvs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    diagnostic-msgs \
    example-interfaces \
    rcl-interfaces \
    rclcpp \
    rclcpp-action \
    ros2-medkit-msgs \
    sensor-msgs \
    std-msgs \
    std-srvs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-index-python \
    launch-ros \
    launch-testing \
    launch-testing-ament-cmake \
    python3-requests \
    ros2-medkit-fault-manager \
    ros2-medkit-gateway \
    ros2-medkit-graph-provider \
    ros2-medkit-linux-introspection \
    ros2-medkit-param-beacon \
    ros2-medkit-topic-beacon \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/ros2_medkit-release/archive/release/jazzy/ros2_medkit_integration_tests/0.4.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/ros2_medkit_integration_tests"
SRC_URI = "git://github.com/ros2-gbp/ros2_medkit-release;${ROS_BRANCH};protocol=https"
SRCREV = "2dc09f8b1fe49aeb7864972a95c0a7c2dd180bff"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

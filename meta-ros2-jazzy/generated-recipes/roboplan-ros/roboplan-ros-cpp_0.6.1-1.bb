# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "ROS 2 C++ bindings for the RoboPlan motion planning library."
AUTHOR = "Sebastian Castro <sebas.a.castro@gmail.com>"
HOMEPAGE = "https://roboplan-ros.readthedocs.io"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "roboplan_ros"
ROS_BPN = "roboplan_ros_cpp"

ROS_BUILD_DEPENDS = "\
    builtin-interfaces \
    geometry-msgs \
    libeigen \
    pinocchio \
    python3 \
    python3-nanobind \
    python3-typing-extensions \
    roboplan \
    rosidl-generator-cpp \
    sensor-msgs \
    tf2-eigen \
    trajectory-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    geometry-msgs \
    libeigen \
    pinocchio \
    roboplan \
    rosidl-generator-cpp \
    sensor-msgs \
    tf2-eigen \
    trajectory-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    geometry-msgs \
    libeigen \
    pinocchio \
    roboplan \
    rosidl-generator-cpp \
    sensor-msgs \
    tf2-eigen \
    trajectory-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-index-cpp \
    roboplan-example-models \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/roboplan_ros-release/archive/release/jazzy/roboplan_ros_cpp/0.6.1-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/roboplan_ros_cpp"
SRC_URI = "git://github.com/ros2-gbp/roboplan_ros-release;${ROS_BRANCH};protocol=https"
SRCREV = "3f96ec3fd8c3452021087b12c8e9e9d9ad79fe6b"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

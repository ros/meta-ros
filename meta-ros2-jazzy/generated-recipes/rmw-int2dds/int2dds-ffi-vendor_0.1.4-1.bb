# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Vendor package that fetches the prebuilt int2DDS FFI library     (shared library + C header) for the host platform and exposes it to     the ROS 2 build as an imported CMake target. Used by rmw_int2dds_cpp."
AUTHOR = "Jungsup Lee <int2dds@int2.us>"
ROS_AUTHOR = "Intellectus Corp. <int2dds@int2.us>"
HOMEPAGE = "https://github.com/IntellectusCorp/int2DDS"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "rmw_int2dds"
ROS_BPN = "int2dds_ffi_vendor"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = ""

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/rmw_int2dds-release/archive/release/jazzy/int2dds_ffi_vendor/0.1.4-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/int2dds_ffi_vendor"
SRC_URI = "git://github.com/ros2-gbp/rmw_int2dds-release;${ROS_BRANCH};protocol=https"
SRCREV = "147e9461ec360b63689b5554db745753b6f4c1cb"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

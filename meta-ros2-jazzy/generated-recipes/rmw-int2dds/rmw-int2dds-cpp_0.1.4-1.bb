# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "ROS 2 middleware (RMW) implementation that binds the int2DDS DDS/RTPS     middleware to the ROS 2 rmw interface."
AUTHOR = "Jungsup Lee <int2dds@int2.us>"
ROS_AUTHOR = "Intellectus Corp. <int2dds@int2.us>"
HOMEPAGE = "https://github.com/IntellectusCorp/int2DDS"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "rmw_int2dds"
ROS_BPN = "rmw_int2dds_cpp"

ROS_BUILD_DEPENDS = "\
    int2dds-ffi-vendor \
    rcutils \
    rmw \
    rmw-dds-common \
    rosidl-dynamic-typesupport \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    int2dds-ffi-vendor \
    rcutils \
    rmw \
    rmw-dds-common \
    rosidl-dynamic-typesupport \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    int2dds-ffi-vendor \
    rcutils \
    rmw \
    rmw-dds-common \
    rosidl-dynamic-typesupport \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-c \
    rosidl-typesupport-cpp \
    rosidl-typesupport-introspection-c \
    rosidl-typesupport-introspection-cpp \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-cpplint \
    ament-cmake-flake8 \
    ament-cmake-gtest \
    ament-cmake-test \
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/rmw_int2dds-release/archive/release/jazzy/rmw_int2dds_cpp/0.1.4-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/rmw_int2dds_cpp"
SRC_URI = "git://github.com/ros2-gbp/rmw_int2dds-release;${ROS_BRANCH};protocol=https"
SRCREV = "ec2d010fa314ef6d0ae3d1d74d6872a2e8c2bbd6"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

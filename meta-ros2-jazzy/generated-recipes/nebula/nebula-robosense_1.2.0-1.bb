# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Nebula Robosense ROS Wrapper"
AUTHOR = "David Wong <david.wong@tier4.jp>"
ROS_AUTHOR = "TIER IV"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "Apache 2"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=fc216ef9336537897fbeafa564601763"

ROS_CN = "nebula"
ROS_BPN = "nebula_robosense"

ROS_BUILD_DEPENDS = "\
    boost \
    diagnostic-msgs \
    diagnostic-updater \
    nebula-core-common \
    nebula-core-decoders \
    nebula-core-hw-interfaces \
    nebula-core-ros \
    nebula-msgs \
    nebula-robosense-common \
    nebula-robosense-decoders \
    nebula-robosense-hw-interfaces \
    rclcpp \
    rclcpp-components \
    robosense-msgs \
    sensor-msgs \
    yaml-cpp \
"

ROS_BUILDTOOL_DEPENDS = "\
    autoware-cmake-native \
    ros-environment-native \
    ros-testing-native \
"

ROS_EXPORT_DEPENDS = "\
    boost \
    diagnostic-msgs \
    diagnostic-updater \
    nebula-core-common \
    nebula-core-decoders \
    nebula-core-hw-interfaces \
    nebula-core-ros \
    nebula-msgs \
    nebula-robosense-common \
    nebula-robosense-decoders \
    nebula-robosense-hw-interfaces \
    rclcpp \
    rclcpp-components \
    robosense-msgs \
    sensor-msgs \
    yaml-cpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    boost \
    diagnostic-msgs \
    diagnostic-updater \
    nebula-core-common \
    nebula-core-decoders \
    nebula-core-hw-interfaces \
    nebula-core-ros \
    nebula-msgs \
    nebula-robosense-common \
    nebula-robosense-decoders \
    nebula-robosense-hw-interfaces \
    rclcpp \
    rclcpp-components \
    robosense-msgs \
    sensor-msgs \
    yaml-cpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-lint-auto \
    ros-testing \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/nebula-release/archive/release/jazzy/nebula_robosense/1.2.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/nebula_robosense"
SRC_URI = "git://github.com/ros2-gbp/nebula-release;${ROS_BRANCH};protocol=https"
SRCREV = "00d399791754072300c5644d58382aa0e8e98256"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

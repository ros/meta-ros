# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Nebula Sample Common Libraries and Headers"
AUTHOR = "David Wong <david.wong@tier4.jp>"
ROS_AUTHOR = "TIER IV"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache 2"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=fc216ef9336537897fbeafa564601763"

ROS_CN = "nebula"
ROS_BPN = "nebula_sample_common"

ROS_BUILD_DEPENDS = " \
    nebula-core-common \
    nebula-core-decoders \
"

ROS_BUILDTOOL_DEPENDS = " \
    autoware-cmake-native \
    ros-environment-native \
"

ROS_EXPORT_DEPENDS = " \
    nebula-core-common \
    nebula-core-decoders \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    nebula-core-common \
    nebula-core-decoders \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/nebula-release/archive/release/jazzy/nebula_sample_common/1.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/nebula_sample_common"
SRC_URI = "git://github.com/ros2-gbp/nebula-release;${ROS_BRANCH};protocol=https"
SRCREV = "4ba29a326a90a5f94da186597bb5d0f2a8ce58aa"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

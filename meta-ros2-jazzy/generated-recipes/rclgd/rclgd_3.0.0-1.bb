# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "GODOT implementation of rclcpp"
AUTHOR = "ozuba <miguelozubas@gmail.com>"
HOMEPAGE = "https://rclgd.readthedocs.io/"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "rclgd"
ROS_BPN = "rclgd"

ROS_BUILD_DEPENDS = "\
    geometry-msgs \
    rclcpp \
    rclcpp-action \
    ros-babel-fish \
    rosgraph-msgs \
    std-msgs \
    tf2-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    geometry-msgs \
    rclcpp \
    rclcpp-action \
    ros-babel-fish \
    rosgraph-msgs \
    std-msgs \
    tf2-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    colcon-rclgd \
    geometry-msgs \
    rclcpp \
    rclcpp-action \
    rclgd-cli \
    ros-babel-fish \
    ros2launch \
    rosgraph-msgs \
    std-msgs \
    tf2-msgs \
    tf2-ros \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-test \
    ament-lint-auto \
    ament-lint-common \
    example-interfaces \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/Ozuba/rclgd-release/archive/release/jazzy/rclgd/3.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/rclgd"
SRC_URI = "git://github.com/Ozuba/rclgd-release;${ROS_BRANCH};protocol=https"
SRCREV = "980cd8f188d82b6618b32e57e3087b3665a3e245"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "ros2cli command entrypoint for NoDL."
AUTHOR = "ROSGraph Working Group <rosgraph-wg@googlegroups.com>"
ROS_AUTHOR = "Alistair English <hello@alistairenglish.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "nodl"
ROS_BPN = "ros2nodl"

ROS_BUILD_DEPENDS = "\
    ament-index-python \
    nodl-conformance \
    nodl-observe \
    nodl-schema \
    rclpy \
    ros2cli \
    rosgraph-msgs \
    rosidl-runtime-py \
"

ROS_BUILDTOOL_DEPENDS = ""

ROS_EXPORT_DEPENDS = "\
    ament-index-python \
    nodl-conformance \
    nodl-observe \
    nodl-schema \
    rclpy \
    ros2cli \
    rosgraph-msgs \
    rosidl-runtime-py \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-index-python \
    nodl-conformance \
    nodl-observe \
    nodl-schema \
    rclpy \
    ros2cli \
    rosgraph-msgs \
    rosidl-runtime-py \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    builtin-interfaces \
    python3-pytest \
    rcl-interfaces \
    std-msgs \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/nodl-release/archive/release/jazzy/ros2nodl/2.0.3-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/ros2nodl"
SRC_URI = "git://github.com/ros2-gbp/nodl-release;${ROS_BRANCH};protocol=https"
SRCREV = "faf581e5c498811c7e3f3153968c76b021d91a04"

ROS_BUILD_TYPE = "ament_python"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Bridge namespaced TF topics into the global TF tree for multi-robot setups"
AUTHOR = "Rafal Gorecki <rafal.gorecki@husarion.com>"
HOMEPAGE = "https://github.com/husarion/tf_namespace_bridge"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "tf_namespace_bridge"
ROS_BPN = "tf_namespace_bridge"

ROS_BUILD_DEPENDS = "\
    generate-parameter-library \
    rclcpp \
    tf2-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    generate-parameter-library \
    rclcpp \
    tf2-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    generate-parameter-library \
    rclcpp \
    tf2-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/husarion/tf_namespace_bridge-release/archive/release/jazzy/tf_namespace_bridge/0.1.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/tf_namespace_bridge"
SRC_URI = "git://github.com/husarion/tf_namespace_bridge-release;${ROS_BRANCH};protocol=https"
SRCREV = "7f8f08143876e51ecda6ed2a638901cc26108def"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

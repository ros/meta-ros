# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Lightweight C++ GUI to inspect a ROS 2 node's live connections and diagnose     broken topic links (QoS incompatibility, type mismatch, dead links)."
AUTHOR = "Chittaranjan Swaminathan <chittaranjan@dynorobotics.se>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "GPL-3.0-only"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=9c2b4f259ad099b703e1cfabd83d05c2"

ROS_CN = "connection_inspector"
ROS_BPN = "connection_inspector"

ROS_BUILD_DEPENDS = "\
    ament-index-cpp \
    glfw \
    mesa \
    rclcpp \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    ament-index-cpp \
    glfw \
    mesa \
    rclcpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-index-cpp \
    glfw \
    mesa \
    rclcpp \
    rclpy \
    ros2launch \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/DynoRobotics/connection_inspector-release/archive/release/jazzy/connection_inspector/1.0.1-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/connection_inspector"
SRC_URI = "git://github.com/DynoRobotics/connection_inspector-release;${ROS_BRANCH};protocol=https"
SRCREV = "ba8af560e987889d3fe52563e7ae2730e180aa9a"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

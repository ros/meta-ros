# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Description of controller_manager"
AUTHOR = "Bence Magyar <bence.magyar.robotics@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "ros2_control"
ROS_BPN = "controller_manager"

ROS_BUILD_DEPENDS = " \
    ament-index-cpp \
    backward-ros \
    controller-interface \
    controller-manager-msgs \
    diagnostic-updater \
    hardware-interface \
    launch \
    launch-ros \
    pluginlib \
    rclcpp \
    rcpputils \
    realtime-tools \
    ros2-control-test-assets \
    ros2param \
    ros2run \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-gen-version-h-native \
    ament-cmake-native \
    ament-cmake-python-native \
"

ROS_EXPORT_DEPENDS = " \
    ament-index-cpp \
    backward-ros \
    controller-interface \
    controller-manager-msgs \
    diagnostic-updater \
    hardware-interface \
    launch \
    launch-ros \
    pluginlib \
    rclcpp \
    rcpputils \
    realtime-tools \
    ros2-control-test-assets \
    ros2param \
    ros2run \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ament-index-cpp \
    backward-ros \
    controller-interface \
    controller-manager-msgs \
    diagnostic-updater \
    hardware-interface \
    launch \
    launch-ros \
    pluginlib \
    rclcpp \
    rcpputils \
    realtime-tools \
    ros2-control-test-assets \
    ros2param \
    ros2run \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-gmock \
    hardware-interface-testing \
    ros2-control-test-assets \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/ros2_control-release/archive/release/jazzy/controller_manager/4.8.0-2.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/controller_manager"
SRC_URI = "git://github.com/ros2-gbp/ros2_control-release;${ROS_BRANCH};protocol=https"
SRCREV = "e8196a03dfdf0a28d257a4cf1d2db72ace5c278a"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

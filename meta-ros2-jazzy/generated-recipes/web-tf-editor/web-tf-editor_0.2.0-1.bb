# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Browser-based, RViz-like 3D viewer for authoring TF frames interactively. Renders the robot     URDF in a web page, lets you place and drag frames with a 6-DoF gizmo, and broadcasts them     on /tf through rosbridge."
AUTHOR = "Farshad Nozad Heravi <f.n.heravi@gmail.com>"
ROS_AUTHOR = "Farshad Nozad Heravi <f.n.heravi@gmail.com>"
HOMEPAGE = "https://github.com/farshad-heravi/web_tf_editor"
SECTION = "devel"
LICENSE = "Apache-2.0 & MIT & BSD-2-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "web_tf_editor"
ROS_BPN = "web_tf_editor"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = ""

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-index-python \
    geometry-msgs \
    joint-state-publisher \
    launch \
    launch-ros \
    rclpy \
    robot-state-publisher \
    rosbridge-server \
    std-msgs \
    tf2-ros-py \
    turtlebot3-manipulation-description \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-copyright \
    ament-flake8 \
    ament-pep257 \
    python3-pytest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/farshad-heravi/web_tf_editor-release/archive/release/jazzy/web_tf_editor/0.2.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/web_tf_editor"
SRC_URI = "git://github.com/farshad-heravi/web_tf_editor-release;${ROS_BRANCH};protocol=https"
SRCREV = "bf3fb617dfea710d974c3662dde268f1773c4711"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_python"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Lyrical RPLIDAR C1 ROS 2 wrapper for LGDXRobot2"
AUTHOR = "LGDXRobot <info@bristolgram.uk>"
ROS_AUTHOR = "LGDXRobot <info@bristolgram.uk>"
HOMEPAGE = "https://lgdxrobot.uk/lgdxrobot2"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "lgdxrobot2_rplidar_c1"
ROS_BPN = "lgdx_rplidar_c1"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    boost-native \
    rclcpp-components-native \
    rclcpp-native \
    sensor-msgs-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    boost \
    rclcpp \
    rclcpp-components \
    sensor-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/lgdxrobot2_rplidar_c1-release/archive/release/jazzy/lgdx_rplidar_c1/1.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/lgdx_rplidar_c1"
SRC_URI = "git://github.com/ros2-gbp/lgdxrobot2_rplidar_c1-release;${ROS_BRANCH};protocol=https"
SRCREV = "8e592e862beca83c07df6bff0bdb51ede8743a89"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

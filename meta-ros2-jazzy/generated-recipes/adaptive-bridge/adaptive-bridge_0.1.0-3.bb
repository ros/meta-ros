# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Adaptive Bridge is a ROS 2 middleware-level proxy that mitigates the         slow-subscriber backpressure coupling problem by decoupling critical         and non-critical subscriber paths. It prevents a degraded subscriber         (e.g. a remote visualisation tool over WiFi) from degrading the         publisher or affecting safety-critical consumers."
AUTHOR = "Kaushalraj Puwar <kaushalrajpuwar@gmail.com>"
ROS_AUTHOR = "Kaushalraj Puwar <kaushalrajpuwar@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=5bb539404d0b40bbfb80f7ad10fa0c2b"

ROS_CN = "adaptive_bridge"
ROS_BPN = "adaptive_bridge"

ROS_BUILD_DEPENDS = "\
    rclpy \
    sensor-msgs \
    std-msgs \
"

ROS_BUILDTOOL_DEPENDS = ""

ROS_EXPORT_DEPENDS = "\
    rclpy \
    sensor-msgs \
    std-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    python3-pyyaml \
    rclpy \
    sensor-msgs \
    std-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
    python3-pytest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/KaushalrajPuwar/adaptive_bridge-release/archive/release/jazzy/adaptive_bridge/0.1.0-3.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/adaptive_bridge"
SRC_URI = "git://github.com/KaushalrajPuwar/adaptive_bridge-release;${ROS_BRANCH};protocol=https"
SRCREV = "493e64482b5e446898a93dbcde2c5f0fc32a2fe8"

ROS_BUILD_TYPE = "ament_python"

inherit ros_${ROS_BUILD_TYPE}

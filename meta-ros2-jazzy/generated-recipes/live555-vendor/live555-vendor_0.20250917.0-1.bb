# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "multimedia RTSP streaming library"
AUTHOR = "Timo Röhling <timo.roehling@fkie.fraunhofer.de>"
HOMEPAGE = "http://www.live555.com/liveMedia/"
SECTION = "devel"
LICENSE = "LGPL-3.0-or-later & BSD-1-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=2903be9d205c3f1ea97d3ba67036ecc5"

ROS_CN = "live555_vendor"
ROS_BPN = "live555_vendor"

ROS_BUILD_DEPENDS = " \
    openssl \
"

ROS_BUILDTOOL_DEPENDS = " \
    cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = ""

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/live555_vendor-release/archive/release/jazzy/live555_vendor/0.20250917.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/live555_vendor"
SRC_URI = "git://github.com/ros2-gbp/live555_vendor-release;${ROS_BRANCH};protocol=https"
SRCREV = "4eac39e4ae88fcc8acce02812a4008578f23d7a9"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Clearpath Tests"
AUTHOR = "Tony Baltovski <tbaltovski@clearpathrobotics.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "clearpath_tests"
ROS_BPN = "clearpath_tests"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = ""

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-stress} \
    can-utils \
    clearpath-config \
    clearpath-generator-common \
    clearpath-motor-msgs \
    clearpath-platform-msgs \
    diagnostic-msgs \
    geometry-msgs \
    nav-msgs \
    rclpy \
    sensor-msgs \
    simple-term-menu-vendor \
    std-msgs \
    tf-transformations \
    tf2-geometry-msgs \
    tf2-msgs \
    wireless-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/clearpath-gbp/clearpath_tests-release/archive/release/jazzy/clearpath_tests/2.3.1-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/clearpath_tests"
SRC_URI = "git://github.com/clearpath-gbp/clearpath_tests-release;${ROS_BRANCH};protocol=https"
SRCREV = "97720b61b85cfc84e7d2f7aa7d24e517b9de8801"

ROS_BUILD_TYPE = "ament_python"

inherit ros_${ROS_BUILD_TYPE}

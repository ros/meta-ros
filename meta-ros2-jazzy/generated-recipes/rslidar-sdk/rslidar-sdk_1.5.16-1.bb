# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "The rslidar_sdk package"
AUTHOR = "robosense <felix.huang@robosense.cn>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "rslidar_sdk"
ROS_BPN = "rslidar_sdk"

ROS_BUILD_DEPENDS = " \
    libpcap \
    rclcpp \
    rslidar-msg \
    sensor-msgs \
    std-msgs \
    yaml-cpp \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    libpcap \
    rclcpp \
    rslidar-msg \
    sensor-msgs \
    std-msgs \
    yaml-cpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    libpcap \
    rclcpp \
    rslidar-msg \
    sensor-msgs \
    std-msgs \
    yaml-cpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/rslidar_sdk-release/archive/release/jazzy/rslidar_sdk/1.5.16-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/rslidar_sdk"
SRC_URI = "git://github.com/ros2-gbp/rslidar_sdk-release;${ROS_BRANCH};protocol=https"
SRCREV = "490b6edae6ef8949c8f9da5a15afc4f578789d18"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

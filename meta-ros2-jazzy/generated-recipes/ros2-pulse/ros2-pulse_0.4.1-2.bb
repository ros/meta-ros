# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Near-zero-overhead ROS 2 probe for per-topic message frequency and active-node liveness,     covering both inter-process and intra-process traffic. Works on stock ROS 2 binaries via an     LD_PRELOAD shim over the tracetools instrumentation layer: no patched rmw_implementation, no     ROS recompile, no privileges, and no DDS traffic."
AUTHOR = "Tanay Kedia <95276223+TanayK07@users.noreply.github.com>"
HOMEPAGE = "https://github.com/TanayK07/ros2_pulse"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "ros2_pulse"
ROS_BPN = "ros2_pulse"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = ""

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-cmake-pytest \
    lttng-tools \
    rclcpp \
    ros2run \
    std-msgs \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/TanayK07/ros2_pulse-release/archive/release/jazzy/ros2_pulse/0.4.1-2.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/ros2_pulse"
SRC_URI = "git://github.com/TanayK07/ros2_pulse-release;${ROS_BRANCH};protocol=https"
SRCREV = "21d04a1ed6d6dd6a8942e10d4b1e6ab6fc437498"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

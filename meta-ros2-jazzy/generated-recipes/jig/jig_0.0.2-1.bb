# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Declarative ROS 2 node scaffolding with built-in best practice."
AUTHOR = "Alistair English <hello@alistairenglish.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "Apache 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=3dce4ba60d7e51ec64f3c3dc18672dd3"

ROS_CN = "jig"
ROS_BPN = "jig"

ROS_BUILD_DEPENDS = "\
    lifecycle-msgs \
    message-filters \
    python3-jinja2 \
    python3-jsonschema \
    python3-pyyaml \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rclcpp-lifecycle \
    rosidl-default-generators \
    tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-auto-native \
    ament-cmake-native \
    ament-cmake-python-native \
    generate-parameter-library-native \
"

ROS_EXPORT_DEPENDS = "\
    lifecycle-msgs \
    message-filters \
    python3-jinja2 \
    python3-jsonschema \
    python3-pyyaml \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rclcpp-lifecycle \
    tf2-ros \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-index-python \
    lifecycle-msgs \
    message-filters \
    python3-jinja2 \
    python3-jsonschema \
    python3-pyyaml \
    rclcpp \
    rclcpp-action \
    rclcpp-components \
    rclcpp-lifecycle \
    rosidl-default-runtime \
    tf2-ros \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-pytest \
    python3-pytest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/jig-release/archive/release/jazzy/jig/0.0.2-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/jig"
SRC_URI = "git://github.com/ros2-gbp/jig-release;${ROS_BRANCH};protocol=https"
SRCREV = "6e32a7d9ed1ad03d342853c9fb7cc0f11f6273d7"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

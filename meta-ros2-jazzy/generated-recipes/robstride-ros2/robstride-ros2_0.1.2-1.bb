# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Aggregate installation package for the RobStride driver, ros2_control component, and examples."
AUTHOR = "yamato <ykturtler@outlook.com>"
HOMEPAGE = "https://github.com/s2015-turtle/robstride_ros2"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "robstride_ros2"
ROS_BPN = "robstride_ros2"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    robstride-driver \
    robstride-examples \
    robstride-ros2-control \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/robstride_ros2-release/archive/release/jazzy/robstride_ros2/0.1.2-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/robstride_ros2"
SRC_URI = "git://github.com/ros2-gbp/robstride_ros2-release;${ROS_BRANCH};protocol=https"
SRCREV = "80c0f22d4920503c9886c2073236561159e31890"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

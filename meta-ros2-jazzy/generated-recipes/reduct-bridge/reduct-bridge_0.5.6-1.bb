# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Streams ROS 2 data into ReductStore."
AUTHOR = "ReductSoftware UG <info@reduct.store>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "reduct_bridge"
ROS_BPN = "reduct_bridge"

ROS_BUILD_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-rustc} \
    builtin-interfaces \
    cargo \
    cmake \
    example-interfaces \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-yaml-param-parser \
    rcutils \
    rmw \
    rmw-implementation \
    ros-environment \
    rosgraph-msgs \
    rosidl-runtime-c \
    test-msgs \
    unique-identifier-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    builtin-interfaces \
    example-interfaces \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-yaml-param-parser \
    rcutils \
    rmw \
    rmw-implementation \
    ros-environment \
    rosgraph-msgs \
    rosidl-runtime-c \
    test-msgs \
    unique-identifier-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    builtin-interfaces \
    example-interfaces \
    rcl \
    rcl-action \
    rcl-interfaces \
    rcl-yaml-param-parser \
    rcutils \
    rmw \
    rmw-implementation \
    ros-environment \
    rosgraph-msgs \
    rosidl-runtime-c \
    test-msgs \
    unique-identifier-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/reduct_bridge-release/archive/release/jazzy/reduct_bridge/0.5.6-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/reduct_bridge"
SRC_URI = "git://github.com/ros2-gbp/reduct_bridge-release;${ROS_BRANCH};protocol=https"
SRCREV = "df9149e731c7f8aef56f38ef5b035d98297823bb"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

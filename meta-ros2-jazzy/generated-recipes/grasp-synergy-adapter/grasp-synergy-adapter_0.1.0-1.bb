# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Map low-dimensional grasp synergies to configurable multi-joint hand trajectories."
AUTHOR = "Sunghyun Kwon <shkwon098@gmail.com>"
ROS_AUTHOR = "Sunghyun Kwon <shkwon098@gmail.com>"
HOMEPAGE = "https://github.com/shkwon98/grasp_synergy_adapter"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=a807c33e2269cc13a057985af3c05efe"

ROS_CN = "grasp_synergy_adapter"
ROS_BPN = "grasp_synergy_adapter"

ROS_BUILD_DEPENDS = "\
    control-msgs \
    rclcpp \
    rclcpp-action \
    trajectory-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    control-msgs \
    rclcpp \
    rclcpp-action \
    trajectory-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    control-msgs \
    rclcpp \
    rclcpp-action \
    trajectory-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    action-msgs \
    ament-cmake-clang-format \
    ament-cmake-flake8 \
    ament-cmake-gtest \
    ament-cmake-lint-cmake \
    ament-cmake-pytest \
    ament-cmake-xmllint \
    ament-index-python \
    ament-lint-auto \
    rclpy \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/grasp_synergy_adapter-release/archive/release/jazzy/grasp_synergy_adapter/0.1.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/grasp_synergy_adapter"
SRC_URI = "git://github.com/ros2-gbp/grasp_synergy_adapter-release;${ROS_BRANCH};protocol=https"
SRCREV = "cc1ed1aa6383db817b515b7320d883d1ff6f638a"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

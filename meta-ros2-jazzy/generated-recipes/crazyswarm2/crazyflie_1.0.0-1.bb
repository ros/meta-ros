# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "ROS 2 Package for Bitcraze Crazyflie robots"
AUTHOR = "Wolfgang Hönig, Kimberly McGuire <hoenig@tu-berlin.de>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "crazyswarm2"
ROS_BPN = "crazyflie"

ROS_BUILD_DEPENDS = " \
    crazyflie-interfaces \
    geometry-msgs \
    motion-capture-tracking-interfaces \
    rclcpp \
    sensor-msgs \
    std-srvs \
    tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
    ament-cmake-python-native \
"

ROS_EXPORT_DEPENDS = " \
    crazyflie-interfaces \
    geometry-msgs \
    motion-capture-tracking-interfaces \
    rclcpp \
    sensor-msgs \
    std-srvs \
    tf2-ros \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    crazyflie-interfaces \
    geometry-msgs \
    motion-capture-tracking-interfaces \
    rclcpp \
    sensor-msgs \
    std-srvs \
    tf-transformations \
    tf2-ros \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/crazyswarm2-release/archive/release/jazzy/crazyflie/1.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/crazyflie"
SRC_URI = "git://github.com/ros2-gbp/crazyswarm2-release;${ROS_BRANCH};protocol=https"
SRCREV = "b384eb5cd52791561f02d750248585b78bb61a2b"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

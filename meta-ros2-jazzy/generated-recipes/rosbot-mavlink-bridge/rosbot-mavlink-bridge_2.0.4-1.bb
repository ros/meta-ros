# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Bridge node that translates the firmware's MAVLink wire protocol into the     same ROS 2 API the micro-ROS agent currently exposes, so downstream     consumers (e.g. rosbot_ros) see byte-identical topics/services. Single     source tree builds for both jazzy and humble (see MAVLINK_MIGRATION.md     D24)."
AUTHOR = "Husarion <support@husarion.com>"
ROS_AUTHOR = "Rafal Gorecki <rafal.gorecki@husarion.com>"
HOMEPAGE = "https://husarion.com/"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "rosbot_mavlink_bridge"
ROS_BPN = "rosbot_mavlink_bridge"

ROS_BUILD_DEPENDS = "\
    rclcpp \
    sensor-msgs \
    std-msgs \
    std-srvs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    rclcpp \
    sensor-msgs \
    std-msgs \
    std-srvs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    rclcpp \
    sensor-msgs \
    std-msgs \
    std-srvs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/husarion/rosbot_mavlink_bridge-release/archive/release/jazzy/rosbot_mavlink_bridge/2.0.4-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/rosbot_mavlink_bridge"
SRC_URI = "git://github.com/husarion/rosbot_mavlink_bridge-release;${ROS_BRANCH};protocol=https"
SRCREV = "cc006ce40eeba7ce3fe1af3770b3f644f66d9fda"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

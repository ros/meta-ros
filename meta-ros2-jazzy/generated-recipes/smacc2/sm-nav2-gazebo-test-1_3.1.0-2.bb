# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Nav2 unit test state machine for SMACC2"
AUTHOR = "User <user@example.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "smacc2"
ROS_BPN = "sm_nav2_gazebo_test_1"

ROS_BUILD_DEPENDS = " \
    cl-keyboard \
    cl-nav2z \
    cl-ros2-timer \
    geometry-msgs \
    smacc2 \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    cl-keyboard \
    cl-nav2z \
    cl-ros2-timer \
    geometry-msgs \
    smacc2 \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    cl-keyboard \
    cl-nav2z \
    cl-ros2-timer \
    geometry-msgs \
    nav2-bringup \
    smacc2 \
    xterm \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/robosoft-ai/SMACC2-release/archive/release/jazzy/sm_nav2_gazebo_test_1/3.1.0-2.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/sm_nav2_gazebo_test_1"
SRC_URI = "git://github.com/robosoft-ai/SMACC2-release;${ROS_BRANCH};protocol=https"
SRCREV = "e0bb5a4aa5040db6e3f2fad9e4ecf2d2e113a19e"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

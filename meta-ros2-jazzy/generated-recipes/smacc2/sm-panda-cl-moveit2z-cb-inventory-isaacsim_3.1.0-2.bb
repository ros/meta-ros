# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "The sm_panda_cl_moveit2z_cb_inventory package adapted for Isaac Sim"
AUTHOR = "Brett Aldrich <brett@robosoft.ai>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "smacc2"
ROS_BPN = "sm_panda_cl_moveit2z_cb_inventory_isaacsim"

ROS_BUILD_DEPENDS = " \
    boost \
    cl-keyboard \
    cl-moveit2z \
    cl-ros2-timer \
    controller-manager \
    joint-state-broadcaster \
    moveit \
    moveit-planners-chomp \
    moveit-planners-ompl \
    moveit-plugins \
    moveit-resources-panda-moveit-config \
    moveit-ros-robot-interaction \
    moveit-simple-controller-manager \
    moveit-visual-tools \
    pilz-industrial-motion-planner \
    rclcpp \
    robot-state-publisher \
    smacc2 \
    yaml-cpp \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    boost \
    cl-keyboard \
    cl-moveit2z \
    cl-ros2-timer \
    controller-manager \
    joint-state-broadcaster \
    moveit \
    moveit-planners-chomp \
    moveit-planners-ompl \
    moveit-plugins \
    moveit-resources-panda-moveit-config \
    moveit-ros-robot-interaction \
    moveit-simple-controller-manager \
    moveit-visual-tools \
    pilz-industrial-motion-planner \
    rclcpp \
    robot-state-publisher \
    smacc2 \
    yaml-cpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-konsole} \
    boost \
    cl-keyboard \
    cl-moveit2z \
    cl-ros2-timer \
    controller-manager \
    joint-state-broadcaster \
    joint-trajectory-controller \
    moveit \
    moveit-planners-chomp \
    moveit-planners-ompl \
    moveit-plugins \
    moveit-resources-panda-moveit-config \
    moveit-ros-robot-interaction \
    moveit-simple-controller-manager \
    moveit-visual-tools \
    pilz-industrial-motion-planner \
    rclcpp \
    robot-state-publisher \
    smacc2 \
    yaml-cpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/robosoft-ai/SMACC2-release/archive/release/jazzy/sm_panda_cl_moveit2z_cb_inventory_isaacsim/3.1.0-2.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/sm_panda_cl_moveit2z_cb_inventory_isaacsim"
SRC_URI = "git://github.com/robosoft-ai/SMACC2-release;${ROS_BRANCH};protocol=https"
SRCREV = "c06abed58bdbc154d4aca0dd4e539221a4a9d1ef"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

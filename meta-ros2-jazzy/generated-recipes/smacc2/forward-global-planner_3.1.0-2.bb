# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "The forward_global_planner package."
AUTHOR = "Pablo Inigo Blasco <pablo@ibrobotics.com>"
ROS_AUTHOR = "Pablo Inigo Blasco <pablo@ibrobotics.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSDv3"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=f53d792e661856727e968bf064d8cc8f"

ROS_CN = "smacc2"
ROS_BPN = "forward_global_planner"

ROS_BUILD_DEPENDS = " \
    geometry-msgs \
    nav-2d-utils \
    nav-msgs \
    nav2-core \
    nav2-costmap-2d \
    nav2z-planners-common \
    pluginlib \
    tf2 \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    geometry-msgs \
    nav-2d-utils \
    nav-msgs \
    nav2-core \
    nav2-costmap-2d \
    nav2z-planners-common \
    tf2 \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    geometry-msgs \
    nav-2d-utils \
    nav-msgs \
    nav2-core \
    nav2-costmap-2d \
    nav2z-planners-common \
    tf2 \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/robosoft-ai/SMACC2-release/archive/release/jazzy/forward_global_planner/3.1.0-2.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/forward_global_planner"
SRC_URI = "git://github.com/robosoft-ai/SMACC2-release;${ROS_BRANCH};protocol=https"
SRCREV = "5d09608adeddcb19f886995a6644037d2c20ddd8"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

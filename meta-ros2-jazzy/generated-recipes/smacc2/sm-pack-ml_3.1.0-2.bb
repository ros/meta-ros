# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "The sm_pack_ml package"
AUTHOR = "geus <pablo@ibrobotics.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "smacc2"
ROS_BPN = "sm_pack_ml"

ROS_BUILD_DEPENDS = " \
    cl-generic-sensor \
    cl-keyboard \
    cl-ros2-timer \
    rclcpp \
    smacc2 \
    sr-all-events-go \
    std-msgs \
    xterm \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    cl-generic-sensor \
    cl-keyboard \
    cl-ros2-timer \
    rclcpp \
    smacc2 \
    sr-all-events-go \
    std-msgs \
    xterm \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    cl-generic-sensor \
    cl-keyboard \
    cl-ros2-timer \
    rclcpp \
    smacc2 \
    sr-all-events-go \
    std-msgs \
    xterm \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/robosoft-ai/SMACC2-release/archive/release/jazzy/sm_pack_ml/3.1.0-2.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/sm_pack_ml"
SRC_URI = "git://github.com/robosoft-ai/SMACC2-release;${ROS_BRANCH};protocol=https"
SRCREV = "54ddd83b0fc6f23e62f3244e1299569943b55b28"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

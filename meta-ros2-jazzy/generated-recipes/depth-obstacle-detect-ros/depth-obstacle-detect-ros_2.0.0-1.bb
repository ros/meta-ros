# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "The depth based obstacle detection package"
AUTHOR = "Analog Devices <ros@analog.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "depth_obstacle_detect_ros"
ROS_BPN = "depth_obstacle_detect_ros"

ROS_BUILD_DEPENDS = " \
    cv-bridge \
    depth-obstacle-detect-ros-msgs \
    image-transport \
    rclcpp \
    rclcpp-components \
    rclpy \
    sensor-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    cv-bridge \
    depth-obstacle-detect-ros-msgs \
    image-transport \
    rclcpp \
    rclcpp-components \
    rclpy \
    sensor-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    cv-bridge \
    depth-obstacle-detect-ros-msgs \
    image-transport \
    rclcpp \
    rclcpp-components \
    rclpy \
    ros2launch \
    sensor-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/depth_obstacle_detect_ros-release/archive/release/jazzy/depth_obstacle_detect_ros/2.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/depth_obstacle_detect_ros"
SRC_URI = "git://github.com/ros2-gbp/depth_obstacle_detect_ros-release;${ROS_BRANCH};protocol=https"
SRCREV = "8c6f3ad126e9c2417eef9d4d8f951e2299727225"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

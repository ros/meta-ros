# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Easy Navigation playground with a Summit XL: EasyNav configurations and launchers for the Summit XL simulation (NavMap and Bonxai with RPP, MPPI and MPC; GPS fusion; warehouse logistics)."
AUTHOR = "Francisco Martín Rico <fmrico@gmail.com>"
ROS_AUTHOR = "Francisco Martín Rico <fmrico@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=a807c33e2269cc13a057985af3c05efe"

ROS_CN = "easynav_playgrounds"
ROS_BPN = "easynav_playground_summit"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    easynav-bonxai-maps-manager \
    easynav-diagnostic-recovery \
    easynav-fusion-localizer \
    easynav-mpc-controller \
    easynav-mppi-controller \
    easynav-navmap-localizer \
    easynav-navmap-maps-manager \
    easynav-navmap-planner \
    easynav-playground-summit-worlds \
    easynav-regulated-pp-controller \
    easynav-serest-controller \
    easynav-simple-controller \
    easynav-system \
    launch \
    launch-ros \
    launch-yaml \
    navmap-rviz-plugin \
    rviz2 \
    sensor-msgs \
    tf2-ros \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/EasyNavigation/easynav_playgrounds-release/archive/release/jazzy/easynav_playground_summit/0.5.1-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/easynav_playground_summit"
SRC_URI = "git://github.com/EasyNavigation/easynav_playgrounds-release;${ROS_BRANCH};protocol=https"
SRCREV = "c67f0b24681eb88fefd8de7f948855717b47d7cb"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Gazebo (Harmonic or newer) simulation of omnidirectional robots for the EasyNav playgrounds: two mazes and their maps, the kinematics node, and the launcher that spawns the chosen robot with its controllers and the ROS-Gazebo bridge."
AUTHOR = "Francisco Martín Rico <fmrico@gmail.com>"
ROS_AUTHOR = "Yohan Prakoso"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT AND Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=ba086732c8b3e09d0a15c4bc717c6c44"

ROS_CN = "easynav_playgrounds"
ROS_BPN = "easynav_playground_omni_worlds"

ROS_BUILD_DEPENDS = "\
    geometry-msgs \
    libeigen \
    nav-msgs \
    rclcpp \
    sensor-msgs \
    std-msgs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    geometry-msgs \
    libeigen \
    nav-msgs \
    rclcpp \
    sensor-msgs \
    std-msgs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    controller-manager \
    easynav-playground-omni-description \
    forward-command-controller \
    geometry-msgs \
    gz-sim-vendor \
    joint-state-broadcaster \
    launch \
    launch-ros \
    launch-yaml \
    libeigen \
    nav-msgs \
    python3 \
    rclcpp \
    rclpy \
    robot-state-publisher \
    ros-gz-bridge \
    ros-gz-sim \
    rviz2 \
    sensor-msgs \
    std-msgs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-copyright \
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/EasyNavigation/easynav_playgrounds-release/archive/release/jazzy/easynav_playground_omni_worlds/0.5.1-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/easynav_playground_omni_worlds"
SRC_URI = "git://github.com/EasyNavigation/easynav_playgrounds-release;${ROS_BRANCH};protocol=https"
SRCREV = "9c88faa36b782cba3407941e2740658b5016aa79"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

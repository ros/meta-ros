# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Easy Navigation playground with a Kobuki: EasyNav configurations and launchers for the Kobuki simulation (costmap with RPP, MPPI, MPC, SeReST, MH-AMCL, routes and safety mode; Simple; mapping; multirobot)."
AUTHOR = "Francisco Martín Rico <fmrico@gmail.com>"
ROS_AUTHOR = "Francisco Martín Rico <fmrico@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=a807c33e2269cc13a057985af3c05efe"

ROS_CN = "easynav_playgrounds"
ROS_BPN = "easynav_playground_kobuki"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-index-python \
    easynav-costmap-localizer \
    easynav-costmap-maps-manager \
    easynav-costmap-planner \
    easynav-diagnostic-recovery \
    easynav-interfaces \
    easynav-mhamcl-localizer \
    easynav-mpc-controller \
    easynav-mppi-controller \
    easynav-playground-kobuki-worlds \
    easynav-regulated-pp-controller \
    easynav-routes-maps-manager \
    easynav-serest-controller \
    easynav-simple-controller \
    easynav-simple-localizer \
    easynav-simple-maps-manager \
    easynav-simple-planner \
    easynav-simple-recovery \
    easynav-system \
    launch \
    launch-ros \
    launch-yaml \
    python3-pyyaml \
    ros2topic \
    rviz2 \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/EasyNavigation/easynav_playgrounds-release/archive/release/jazzy/easynav_playground_kobuki/0.5.1-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/easynav_playground_kobuki"
SRC_URI = "git://github.com/EasyNavigation/easynav_playgrounds-release;${ROS_BRANCH};protocol=https"
SRCREV = "8b3566c1f974bdab28d741beaa20d2e6db87a5dc"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

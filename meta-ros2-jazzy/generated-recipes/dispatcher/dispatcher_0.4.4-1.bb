# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Qt-based ROS 2 application for launching and monitoring     ROS nodes and arbitrary processes."
AUTHOR = "Kristopher Wehage <kwehage@jpl.nasa.gov>"
ROS_AUTHOR = "Dennis Wai <Dennis.Wai@jpl.nasa.gov>"
HOMEPAGE = "https://github.com/nasa-jpl/dispatcher"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=19;endline=19;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "dispatcher"
ROS_BPN = "dispatcher"

ROS_BUILD_DEPENDS = "\
    builtin-interfaces \
    qtbase \
    rclcpp \
    sensor-msgs \
    std-msgs \
    std-srvs \
    yaml-cpp \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    builtin-interfaces \
    qtbase \
    rclcpp \
    sensor-msgs \
    std-msgs \
    std-srvs \
    yaml-cpp \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    builtin-interfaces \
    qtbase \
    rclcpp \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tmux \
    yaml-cpp \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/dispatcher-release/archive/release/jazzy/dispatcher/0.4.4-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/dispatcher"
SRC_URI = "git://github.com/ros2-gbp/dispatcher-release;${ROS_BRANCH};protocol=https"
SRCREV = "37f6d7b19e8b1d6cb2420c510fc82537e6d40e18"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

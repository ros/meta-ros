# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "RViz panel plugin for interactively building and editing URDF robot models."
AUTHOR = "Masayoshi Dohi <m.dohi@tobas.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "GPL-3.0-or-later"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=5f660bce20dfd88ba2749c28f85619d4"

ROS_CN = "tobas"
ROS_BPN = "tobas_urdf_builder_plugin"

ROS_BUILD_DEPENDS = "\
    qtbase \
    rviz-common \
    rviz-default-plugins \
    rviz-rendering \
    tobas-constants \
    tobas-property-client \
    tobas-qt-tools \
    tobas-ros2-tools \
    tobas-std-tools \
    tobas-urdf \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    qtbase \
    rviz-common \
    rviz-default-plugins \
    rviz-rendering \
    tobas-constants \
    tobas-property-client \
    tobas-qt-tools \
    tobas-ros2-tools \
    tobas-std-tools \
    tobas-urdf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    qtbase \
    rviz-common \
    rviz-default-plugins \
    rviz-rendering \
    tobas-constants \
    tobas-property-client \
    tobas-qt-tools \
    tobas-ros2-tools \
    tobas-std-tools \
    tobas-urdf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/tobas-release/archive/release/jazzy/tobas_urdf_builder_plugin/2.16.5-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/tobas_urdf_builder_plugin"
SRC_URI = "git://github.com/ros2-gbp/tobas-release;${ROS_BRANCH};protocol=https"
SRCREV = "11b4ba674308d85d13c906cc61cbb18748b75551"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Qt application for recording, viewing, and plotting Tobas flight logs."
AUTHOR = "Masayoshi Dohi <m.dohi@tobas.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "GPL-3.0-or-later"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=5f660bce20dfd88ba2749c28f85619d4"

ROS_CN = "tobas"
ROS_BPN = "tobas_flight_log_gui"

ROS_BUILD_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libquazip1-qt5-dev} \
    tobas-debug-msgs \
    tobas-gui-common \
    tobas-kdl \
    tobas-msgs \
    tobas-property-client \
    tobas-qt-tools \
    tobas-qwt-wrapper \
    tobas-ros2-tools \
    tobas-rqt-bridge \
    tobas-string-tools \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libquazip1-qt5-dev} \
    tobas-debug-msgs \
    tobas-gui-common \
    tobas-kdl \
    tobas-msgs \
    tobas-property-client \
    tobas-qt-tools \
    tobas-qwt-wrapper \
    tobas-ros2-tools \
    tobas-rqt-bridge \
    tobas-string-tools \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libquazip1-qt5-dev} \
    tobas-debug-msgs \
    tobas-gui-common \
    tobas-kdl \
    tobas-msgs \
    tobas-property-client \
    tobas-qt-tools \
    tobas-qwt-wrapper \
    tobas-ros2-tools \
    tobas-rqt-bridge \
    tobas-string-tools \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/tobas-release/archive/release/jazzy/tobas_flight_log_gui/2.16.5-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/tobas_flight_log_gui"
SRC_URI = "git://github.com/ros2-gbp/tobas-release;${ROS_BRANCH};protocol=https"
SRCREV = "a5c5862c3c9d35ffe6a7d5a4b1bc1e0755507ee8"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

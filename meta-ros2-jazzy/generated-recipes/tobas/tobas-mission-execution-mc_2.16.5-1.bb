# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Multicopter mission executor and stop-trajectory generator."
AUTHOR = "Masayoshi Dohi <m.dohi@tobas.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "GPL-3.0-or-later"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=1b4ad776ba35de4c9ebeaed048833302"

ROS_CN = "tobas"
ROS_BPN = "tobas_mission_execution_mc"

ROS_BUILD_DEPENDS = "\
    tobas-command-msgs-adapter \
    tobas-geographic \
    tobas-mission-items \
    tobas-mission-msgs \
    tobas-msgs-adapter \
    tobas-node \
    tobas-trajectory-generation \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    tobas-command-msgs-adapter \
    tobas-geographic \
    tobas-mission-items \
    tobas-mission-msgs \
    tobas-msgs-adapter \
    tobas-node \
    tobas-trajectory-generation \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    tobas-command-msgs-adapter \
    tobas-geographic \
    tobas-mission-items \
    tobas-mission-msgs \
    tobas-msgs-adapter \
    tobas-node \
    tobas-trajectory-generation \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/tobas-release/archive/release/jazzy/tobas_mission_execution_mc/2.16.5-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/tobas_mission_execution_mc"
SRC_URI = "git://github.com/ros2-gbp/tobas-release;${ROS_BRANCH};protocol=https"
SRCREV = "2d6e90e4783eaed291417fb5f03fd58e662fe2ee"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

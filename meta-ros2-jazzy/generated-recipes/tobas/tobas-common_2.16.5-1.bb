# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Aggregation package for reusable Tobas C++ and ROS 2 utility libraries."
AUTHOR = "Masayoshi Dohi <m.dohi@tobas.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "GPL-3.0-or-later"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=1b4ad776ba35de4c9ebeaed048833302"

ROS_CN = "tobas"
ROS_BPN = "tobas_common"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    tobas-algorithm \
    tobas-control \
    tobas-dsp \
    tobas-eigen-conversions \
    tobas-eigen-msgs \
    tobas-eigen-msgs-adapter \
    tobas-eigen-tools \
    tobas-geographic \
    tobas-ic-drivers \
    tobas-ic-drivers-ros \
    tobas-kdl \
    tobas-kdl-conversions \
    tobas-kdl-msgs \
    tobas-kdl-msgs-adapter \
    tobas-linux \
    tobas-math \
    tobas-nlp \
    tobas-path-tools \
    tobas-quadprog \
    tobas-ros2-tools \
    tobas-std-msgs \
    tobas-std-msgs-adapter \
    tobas-std-tools \
    tobas-string-tools \
    tobas-time-tools \
    tobas-trajectory-generation \
    tobas-urdf \
    tobas-xml-tools \
    tobas-yaml-tools \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/tobas-release/archive/release/jazzy/tobas_common/2.16.5-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/tobas_common"
SRC_URI = "git://github.com/ros2-gbp/tobas-release;${ROS_BRANCH};protocol=https"
SRCREV = "4dc4c6ded367f1382730abe203a74f66031c69d8"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

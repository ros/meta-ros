# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Qt application for calibrating Tobas accelerometers, magnetometers, and RC input."
AUTHOR = "Masayoshi Dohi <m.dohi@tobas.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "GPL-3.0-or-later"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=5f660bce20dfd88ba2749c28f85619d4"

ROS_CN = "tobas"
ROS_BPN = "tobas_sensor_calibration"

ROS_BUILD_DEPENDS = "\
    geometry-msgs \
    sensor-msgs \
    tobas-drone-core \
    tobas-eigen-conversions \
    tobas-geographic \
    tobas-gui-common \
    tobas-kdl-conversions \
    tobas-property-tree \
    tobas-qt-tools \
    tobas-real-common \
    tobas-real-msgs \
    tobas-rqt-bridge \
    tobas-rviz-wrapper \
    tobas-time-tools \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    geometry-msgs \
    sensor-msgs \
    tobas-drone-core \
    tobas-eigen-conversions \
    tobas-geographic \
    tobas-gui-common \
    tobas-kdl-conversions \
    tobas-property-tree \
    tobas-qt-tools \
    tobas-real-common \
    tobas-real-msgs \
    tobas-rqt-bridge \
    tobas-rviz-wrapper \
    tobas-time-tools \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    geometry-msgs \
    sensor-msgs \
    tobas-drone-core \
    tobas-eigen-conversions \
    tobas-geographic \
    tobas-gui-common \
    tobas-kdl-conversions \
    tobas-property-tree \
    tobas-qt-tools \
    tobas-real-common \
    tobas-real-msgs \
    tobas-rqt-bridge \
    tobas-rviz-wrapper \
    tobas-time-tools \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/tobas-release/archive/release/jazzy/tobas_sensor_calibration/2.16.5-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/tobas_sensor_calibration"
SRC_URI = "git://github.com/ros2-gbp/tobas-release;${ROS_BRANCH};protocol=https"
SRCREV = "1a6427a1900ee6c354ae2bc472a4eb979e7cec90"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

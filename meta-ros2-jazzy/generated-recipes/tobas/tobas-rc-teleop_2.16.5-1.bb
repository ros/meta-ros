# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "RC-input teleoperation controllers that generate flight commands for multiple control modes."
AUTHOR = "Masayoshi Dohi <m.dohi@tobas.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "GPL-3.0-or-later"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=1b4ad776ba35de4c9ebeaed048833302"

ROS_CN = "tobas"
ROS_BPN = "tobas_rc_teleop"

ROS_BUILD_DEPENDS = "\
    magic-enum \
    tobas-command-msgs-adapter \
    tobas-msgs-adapter \
    tobas-node \
    tobas-path-tools \
    tobas-ros2-tools \
    tobas-trajectory-generation \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    magic-enum \
    tobas-command-msgs-adapter \
    tobas-msgs-adapter \
    tobas-node \
    tobas-path-tools \
    tobas-ros2-tools \
    tobas-trajectory-generation \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    magic-enum \
    tobas-command-msgs-adapter \
    tobas-msgs-adapter \
    tobas-node \
    tobas-path-tools \
    tobas-ros2-tools \
    tobas-trajectory-generation \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/tobas-release/archive/release/jazzy/tobas_rc_teleop/2.16.5-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/tobas_rc_teleop"
SRC_URI = "git://github.com/ros2-gbp/tobas-release;${ROS_BRANCH};protocol=https"
SRCREV = "83ae5608fbf6013254407c46017e2aa50bcc5372"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

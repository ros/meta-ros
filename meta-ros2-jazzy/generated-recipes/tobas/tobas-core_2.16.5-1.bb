# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Aggregation package for the Tobas core flight-control stack."
AUTHOR = "Masayoshi Dohi <m.dohi@tobas.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "GPL-3.0-or-later"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=1b4ad776ba35de4c9ebeaed048833302"

ROS_CN = "tobas"
ROS_BPN = "tobas_core"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    tobas-camera \
    tobas-command-msgs \
    tobas-command-msgs-adapter \
    tobas-common \
    tobas-components-rt \
    tobas-config-servers \
    tobas-connection-monitor \
    tobas-constants \
    tobas-controllers \
    tobas-cui \
    tobas-debug-msgs \
    tobas-debug-msgs-adapter \
    tobas-debug-tools \
    tobas-description \
    tobas-disturbance-observer \
    tobas-dparam \
    tobas-drone \
    tobas-dummy-pkg \
    tobas-eskf \
    tobas-failsafe \
    tobas-fake-publishers \
    tobas-hardware \
    tobas-joint-states-bridge \
    tobas-landing-detection \
    tobas-manipulation \
    tobas-mission \
    tobas-msgs \
    tobas-msgs-adapter \
    tobas-node \
    tobas-object-avoidance \
    tobas-pose-pid \
    tobas-property \
    tobas-rc-teleop \
    tobas-real \
    tobas-ros-interface \
    tobas-rosbag-recorder \
    tobas-rotor-anomaly-detection \
    tobas-rotor-controller \
    tobas-tools \
    tobas-topic-throttle \
    tobas-tree-server \
    tobas-version \
    tobas-vibration-filter \
    tobas-wind-model \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/tobas-release/archive/release/jazzy/tobas_core/2.16.5-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/tobas_core"
SRC_URI = "git://github.com/ros2-gbp/tobas-release;${ROS_BRANCH};protocol=https"
SRCREV = "22ceff082622782026476ff4109142bc821bcbf7"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

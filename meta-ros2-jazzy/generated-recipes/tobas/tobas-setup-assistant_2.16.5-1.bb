# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Qt setup assistant for configuring Tobas projects, vehicles, and runtime environments."
AUTHOR = "Masayoshi Dohi <m.dohi@tobas.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "GPL-3.0-or-later"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=5f660bce20dfd88ba2749c28f85619d4"

ROS_CN = "tobas"
ROS_BPN = "tobas_setup_assistant"

ROS_BUILD_DEPENDS = "\
    magic-enum \
    sensor-msgs \
    tobas-drone-msgs-adapter \
    tobas-git \
    tobas-gui-common \
    tobas-inja-vendor \
    tobas-kdl-parser \
    tobas-path-tools \
    tobas-property-client \
    tobas-qt-tools \
    tobas-rapidcsv-vendor \
    tobas-ros2-tools \
    tobas-rviz-wrapper \
    tobas-string-tools \
    tobas-uadf \
    tobas-urdf \
    tobas-visualization-msgs \
    tobas-xml-tools \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    magic-enum \
    sensor-msgs \
    tobas-drone-msgs-adapter \
    tobas-git \
    tobas-gui-common \
    tobas-inja-vendor \
    tobas-kdl-parser \
    tobas-path-tools \
    tobas-property-client \
    tobas-qt-tools \
    tobas-rapidcsv-vendor \
    tobas-ros2-tools \
    tobas-rviz-wrapper \
    tobas-string-tools \
    tobas-uadf \
    tobas-urdf \
    tobas-visualization-msgs \
    tobas-xml-tools \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    hardware-interface \
    launch \
    launch-ros \
    magic-enum \
    robot-state-publisher \
    sensor-msgs \
    tobas-drone-msgs-adapter \
    tobas-git \
    tobas-gui-common \
    tobas-inja-vendor \
    tobas-kdl-parser \
    tobas-path-tools \
    tobas-property-client \
    tobas-property-server \
    tobas-qt-tools \
    tobas-rapidcsv-vendor \
    tobas-ros2-tools \
    tobas-rviz-plugin \
    tobas-rviz-wrapper \
    tobas-string-tools \
    tobas-uadf \
    tobas-urdf \
    tobas-visualization-msgs \
    tobas-xml-tools \
    visualization-msgs \
    xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/tobas-release/archive/release/jazzy/tobas_setup_assistant/2.16.5-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/tobas_setup_assistant"
SRC_URI = "git://github.com/ros2-gbp/tobas-release;${ROS_BRANCH};protocol=https"
SRCREV = "f3316c1281889378cec72c52ca1c70e59351baaa"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "ROS 2 handlers for real IMU, magnetometer, RC, joint, CPU, and propulsion-system data."
AUTHOR = "Masayoshi Dohi <m.dohi@tobas.jp>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "GPL-3.0-or-later"
LIC_FILES_CHKSUM = "file://package.xml;beginline=7;endline=7;md5=1b4ad776ba35de4c9ebeaed048833302"

ROS_CN = "tobas"
ROS_BPN = "tobas_real_ros"

ROS_BUILD_DEPENDS = "\
    magic-enum \
    sensor-msgs \
    tobas-drone-msgs-adapter \
    tobas-dsp \
    tobas-linux \
    tobas-msgs-adapter \
    tobas-node \
    tobas-property-tree \
    tobas-real-common \
    tobas-real-msgs \
    tobas-string-tools \
    tobas-tools \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    magic-enum \
    sensor-msgs \
    tobas-drone-msgs-adapter \
    tobas-dsp \
    tobas-linux \
    tobas-msgs-adapter \
    tobas-node \
    tobas-property-tree \
    tobas-real-common \
    tobas-real-msgs \
    tobas-string-tools \
    tobas-tools \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    magic-enum \
    sensor-msgs \
    tobas-drone-msgs-adapter \
    tobas-dsp \
    tobas-linux \
    tobas-msgs-adapter \
    tobas-node \
    tobas-property-tree \
    tobas-real-common \
    tobas-real-msgs \
    tobas-string-tools \
    tobas-tools \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/tobas-release/archive/release/jazzy/tobas_real_ros/2.16.5-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/tobas_real_ros"
SRC_URI = "git://github.com/ros2-gbp/tobas-release;${ROS_BRANCH};protocol=https"
SRCREV = "e62a5d3f25768d68ea301782728948020b62d402"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

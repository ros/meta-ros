# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Run a candidate node beside a production node on live inputs, compare their outputs, and report behavioural divergence without letting the candidate reach hardware."
AUTHOR = "Puja <catplotlib@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "ros2_shadow"
ROS_BPN = "ros2_shadow"

ROS_BUILD_DEPENDS = "\
    diagnostic-msgs \
    geometry-msgs \
    nav-msgs \
    python3-numpy \
    python3-pyyaml \
    rclpy \
    rosidl-runtime-py \
    trajectory-msgs \
"

ROS_BUILDTOOL_DEPENDS = ""

ROS_EXPORT_DEPENDS = "\
    diagnostic-msgs \
    geometry-msgs \
    nav-msgs \
    python3-numpy \
    python3-pyyaml \
    rclpy \
    rosidl-runtime-py \
    trajectory-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    diagnostic-msgs \
    geometry-msgs \
    nav-msgs \
    python3-numpy \
    python3-pyyaml \
    rclpy \
    rosidl-runtime-py \
    trajectory-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-copyright \
    ament-flake8 \
    python3-pytest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/catplotlib/ros2_shadow-release/archive/release/jazzy/ros2_shadow/0.1.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/ros2_shadow"
SRC_URI = "git://github.com/catplotlib/ros2_shadow-release;${ROS_BRANCH};protocol=https"
SRCREV = "b4ac23c6f0d7b6416a68412fbf7d5ca4d19dad5a"

ROS_BUILD_TYPE = "ament_python"

inherit ros_${ROS_BUILD_TYPE}

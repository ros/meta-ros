# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Runnable demonstrations of ros2_shadow, including two Nav2 planners compared live on one map."
AUTHOR = "Puja <catplotlib@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "ros2_shadow"
ROS_BPN = "ros2_shadow_demos"

ROS_BUILD_DEPENDS = "\
    geometry-msgs \
    nav-msgs \
    nav2-msgs \
    rclpy \
    ros2-shadow \
    visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = ""

ROS_EXPORT_DEPENDS = "\
    geometry-msgs \
    nav-msgs \
    nav2-msgs \
    rclpy \
    ros2-shadow \
    visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    geometry-msgs \
    nav-msgs \
    nav2-bringup \
    nav2-lifecycle-manager \
    nav2-map-server \
    nav2-msgs \
    nav2-planner \
    rclpy \
    ros2-shadow \
    tf2-ros \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/catplotlib/ros2_shadow-release/archive/release/jazzy/ros2_shadow_demos/0.1.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/ros2_shadow_demos"
SRC_URI = "git://github.com/catplotlib/ros2_shadow-release;${ROS_BRANCH};protocol=https"
SRCREV = "5cc5dffd134e8ebd187f85995e6a2df0dc9b1b89"

ROS_BUILD_TYPE = "ament_python"

inherit ros_${ROS_BUILD_TYPE}

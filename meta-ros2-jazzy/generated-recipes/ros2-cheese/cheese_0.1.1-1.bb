# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Trigger-based image capture node for raw and compressed camera topics."
AUTHOR = "Howard <makubex49@gmail.com>"
ROS_AUTHOR = "Howard <makubex49@gmail.com>"
HOMEPAGE = "https://github.com/HowardWhile/ros2_cheese"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "ros2_cheese"
ROS_BPN = "cheese"

ROS_BUILD_DEPENDS = "\
    cheese-interfaces \
    cv-bridge \
    nlohmann-json \
    opencv \
    rclcpp \
    sensor-msgs \
    std-msgs \
    std-srvs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    cheese-interfaces \
    cv-bridge \
    nlohmann-json \
    opencv \
    rclcpp \
    sensor-msgs \
    std-msgs \
    std-srvs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    cheese-interfaces \
    cv-bridge \
    launch \
    launch-ros \
    nlohmann-json \
    opencv \
    rclcpp \
    sensor-msgs \
    std-msgs \
    std-srvs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-auto \
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/HowardWhile/ros2_cheese-release/archive/release/jazzy/cheese/0.1.1-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/cheese"
SRC_URI = "git://github.com/HowardWhile/ros2_cheese-release;${ROS_BRANCH};protocol=https"
SRCREV = "955e2e322db69559fbb78510140f0ae13bf7c8b3"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

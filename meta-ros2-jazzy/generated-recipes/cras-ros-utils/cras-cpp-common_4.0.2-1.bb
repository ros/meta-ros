# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "A Czech-army knife for ROS code written in C++."
AUTHOR = "Martin Pecka <peckama2@fel.cvut.cz>"
ROS_AUTHOR = "Martin Pecka <peckama2@fel.cvut.cz>"
HOMEPAGE = "https://index.ros.org/p/cras_cpp_common"
SECTION = "devel"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=14;endline=14;md5=4633480cdd27d7906aaf3ef4b72014b2"

ROS_CN = "cras_ros_utils"
ROS_BPN = "cras_cpp_common"

ROS_BUILD_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libexpected-dev} \
    backward-ros \
    boost \
    builtin-interfaces \
    filters \
    fmt \
    geometry-msgs \
    libeigen \
    rcl \
    rclcpp \
    rclcpp-components \
    rcutils \
    rmw \
    sensor-msgs \
    tf2 \
    tf2-eigen \
    tf2-geometry-msgs \
    urdf \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-gen-version-h-native \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-libexpected-dev} \
    builtin-interfaces \
    filters \
    fmt \
    geometry-msgs \
    libeigen \
    rcl \
    rclcpp \
    rclcpp-components \
    rcutils \
    rmw \
    sensor-msgs \
    tf2 \
    tf2-eigen \
    urdf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-language-pack-en} \
    ${ROS_UNRESOLVED_DEP-libexpected-dev} \
    backward-ros \
    boost \
    builtin-interfaces \
    filters \
    fmt \
    geometry-msgs \
    libeigen \
    rcl \
    rclcpp \
    rclcpp-components \
    rcutils \
    rmw \
    sensor-msgs \
    tf2 \
    tf2-eigen \
    tf2-geometry-msgs \
    urdf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    ament-cmake-ros \
    cras-lint \
    std-msgs \
    tf2 \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/cras_ros_utils-release/archive/release/jazzy/cras_cpp_common/4.0.2-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/cras_cpp_common"
SRC_URI = "git://github.com/ros2-gbp/cras_ros_utils-release;${ROS_BRANCH};protocol=https"
SRCREV = "528d9d1d0da886a661122065d5e90073594fc46b"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Vendor package for: gz-gui8 8.1.1      Gazebo GUI : Graphical interfaces for robotics applications"
AUTHOR = "Addisu Z. Taddese <addisuzt@intrinsic.ai>"
HOMEPAGE = "https://github.com/gazebosim/gz-rendering"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=20;endline=20;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "gz_gui_vendor"
ROS_BPN = "gz_gui_vendor"

ROS_BUILD_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-qml-module-qt-labs-folderlistmodel} \
    ${ROS_UNRESOLVED_DEP-qml-module-qt-labs-platform} \
    ${ROS_UNRESOLVED_DEP-qml-module-qt-labs-settings} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtcharts} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtgraphicaleffects} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtlocation} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtpositioning} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtquick-controls2} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtquick-controls} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtquick-dialogs} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtquick-extras} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtquick-layouts} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtquick-templates2} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtquick-window2} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtquick2} \
    ${ROS_UNRESOLVED_DEP-qtquickcontrols2-5-dev} \
    gz-cmake-vendor \
    gz-common-vendor \
    gz-math-vendor \
    gz-msgs-vendor \
    gz-plugin-vendor \
    gz-rendering-vendor \
    gz-tools-vendor \
    gz-transport-vendor \
    gz-utils-vendor \
    libtinyxml2 \
    protobuf \
    qtbase \
    qtdeclarative \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-core-native \
    ament-cmake-test-native \
    ament-cmake-vendor-package-native \
"

ROS_EXPORT_DEPENDS = " \
    gz-cmake-vendor \
    gz-common-vendor \
    gz-math-vendor \
    gz-msgs-vendor \
    gz-plugin-vendor \
    gz-rendering-vendor \
    gz-tools-vendor \
    gz-transport-vendor \
    gz-utils-vendor \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-qml-module-qt-labs-folderlistmodel} \
    ${ROS_UNRESOLVED_DEP-qml-module-qt-labs-platform} \
    ${ROS_UNRESOLVED_DEP-qml-module-qt-labs-settings} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtcharts} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtgraphicaleffects} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtlocation} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtpositioning} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtquick-controls2} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtquick-controls} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtquick-dialogs} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtquick-extras} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtquick-layouts} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtquick-templates2} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtquick-window2} \
    ${ROS_UNRESOLVED_DEP-qml-module-qtquick2} \
    ${ROS_UNRESOLVED_DEP-qtquickcontrols2-5-dev} \
    gz-cmake-vendor \
    gz-common-vendor \
    gz-math-vendor \
    gz-msgs-vendor \
    gz-plugin-vendor \
    gz-rendering-vendor \
    gz-tools-vendor \
    gz-transport-vendor \
    gz-utils-vendor \
    libtinyxml2 \
    protobuf \
    qtbase \
    qtdeclarative \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ${ROS_UNRESOLVED_DEP-xvfb} \
    ament-cmake-copyright \
    ament-cmake-lint-cmake \
    ament-cmake-xmllint \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/gz_gui_vendor-release/archive/release/jazzy/gz_gui_vendor/0.0.2-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/gz_gui_vendor"
SRC_URI = "git://github.com/ros2-gbp/gz_gui_vendor-release;${ROS_BRANCH};protocol=https"
SRCREV = "7ec1c2654c715d58d3439c7dafc6470aebb3addf"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

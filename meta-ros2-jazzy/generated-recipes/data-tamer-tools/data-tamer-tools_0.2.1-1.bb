# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Set of tools for using Foxglove with data tamer"
AUTHOR = "Jordan Lack <jlack1987@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "data_tamer_tools"
ROS_BPN = "data_tamer_tools"

ROS_BUILD_DEPENDS = " \
    backward-ros \
    data-tamer-cpp \
    data-tamer-msgs \
    foxglove-sdk-vendor \
    mcap-vendor \
    nlohmann-json \
    protobuf \
    rcl-interfaces \
    rclcpp \
    rclcpp-components \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
    rosidl-default-generators-native \
"

ROS_EXPORT_DEPENDS = " \
    backward-ros \
    data-tamer-cpp \
    data-tamer-msgs \
    foxglove-sdk-vendor \
    mcap-vendor \
    nlohmann-json \
    protobuf \
    rcl-interfaces \
    rclcpp \
    rclcpp-components \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    backward-ros \
    data-tamer-cpp \
    data-tamer-msgs \
    foxglove-sdk-vendor \
    mcap-vendor \
    nlohmann-json \
    protobuf \
    rcl-interfaces \
    rclcpp \
    rclcpp-components \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = " \
    ament-cmake-clang-format \
    ament-cmake-cppcheck \
    ament-cmake-gtest \
    ament-cmake-lint-cmake \
    ament-index-cpp \
    ament-lint \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/jlack1987/data_tamer_tools-release/archive/release/jazzy/data_tamer_tools/0.2.1-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/data_tamer_tools"
SRC_URI = "git://github.com/jlack1987/data_tamer_tools-release;${ROS_BRANCH};protocol=https"
SRCREV = "d88e2092b4cded66caf76dd621d21727a1fbbc9b"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

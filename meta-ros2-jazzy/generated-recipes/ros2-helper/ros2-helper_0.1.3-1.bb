# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Terminal-first helper tools for ROS 2"
AUTHOR = "Namheon Baek <7nbaek@gmail.com>"
HOMEPAGE = "https://github.com/codevilot/ros2-helper"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=82f0323c08605e5b6f343b05213cf7cc"

ROS_CN = "ros2_helper"
ROS_BPN = "ros2_helper"

ROS_BUILD_DEPENDS = "\
    rclcpp \
    sensor-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    ament-cmake-python-native \
"

ROS_EXPORT_DEPENDS = "\
    rclcpp \
    sensor-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-chafa} \
    python3 \
    rclcpp \
    ros2cli \
    ros2node \
    ros2service \
    ros2topic \
    sensor-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/codevilot/ros2-helper-release/archive/release/jazzy/ros2_helper/0.1.3-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/ros2_helper"
SRC_URI = "git://github.com/codevilot/ros2-helper-release;${ROS_BRANCH};protocol=https"
SRCREV = "0a298c36f8e6f115e0a16f64328c0b3a2d7f1c6a"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

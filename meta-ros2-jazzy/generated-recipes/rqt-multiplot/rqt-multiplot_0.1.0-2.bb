# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "rqt_multiplot provides a GUI plugin for visualizing numeric values in multiple 2D plots using the Qwt plotting backend."
AUTHOR = "Samuel Bachmann <sbachmann@anybotics.com>"
ROS_AUTHOR = "Ralf Kaestner <ralf.kaestner@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "GNU Lesser General Public License v3.0 (LGPL-3.0)"
LICENSE = "GNU-Lesser-General-Public-License-v3.0-LGPL-3.0-"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=25662ba3d423d771dd932bfb3f95da60"

ROS_CN = "rqt_multiplot"
ROS_BPN = "rqt_multiplot"

ROS_BUILD_DEPENDS = "\
    ament-index-cpp \
    boost \
    fastcdr \
    pluginlib \
    qt-gui-cpp \
    qtbase \
    qtsvg \
    qwt-qt5 \
    rcl \
    rclcpp \
    ros-babel-fish \
    rosbag2-cpp \
    rosbag2-storage \
    rosbag2-storage-default-plugins \
    rosbag2-storage-mcap \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-introspection-cpp \
    rqt-gui \
    rqt-gui-cpp \
    type-description-interfaces \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    ament-index-cpp \
    boost \
    fastcdr \
    pluginlib \
    qt-gui-cpp \
    qtbase \
    qtsvg \
    qwt-qt5 \
    rcl \
    rclcpp \
    ros-babel-fish \
    rosbag2-cpp \
    rosbag2-storage \
    rosbag2-storage-default-plugins \
    rosbag2-storage-mcap \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-introspection-cpp \
    rqt-gui \
    rqt-gui-cpp \
    type-description-interfaces \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ament-index-cpp \
    boost \
    diagnostic-msgs \
    fastcdr \
    geometry-msgs \
    pluginlib \
    qt-gui-cpp \
    qtbase \
    qtsvg \
    qwt-qt5 \
    rcl \
    rclcpp \
    rclpy \
    ros-babel-fish \
    rosbag2-cpp \
    rosbag2-storage \
    rosbag2-storage-default-plugins \
    rosbag2-storage-mcap \
    rosidl-runtime-c \
    rosidl-runtime-cpp \
    rosidl-typesupport-fastrtps-cpp \
    rosidl-typesupport-introspection-cpp \
    rqt-gui \
    rqt-gui-cpp \
    sensor-msgs \
    std-msgs \
    type-description-interfaces \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-clang-format \
    ament-cmake-gtest \
    builtin-interfaces \
    clang \
    diagnostic-msgs \
    geometry-msgs \
    rmw-cyclonedds-cpp \
    rmw-fastrtps-cpp \
    rmw-zenoh-cpp \
    rosbag2-storage-mcap \
    sensor-msgs \
    std-msgs \
    test-msgs \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/rqt_multiplot_plugin-release/archive/release/jazzy/rqt_multiplot/0.1.0-2.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/rqt_multiplot"
SRC_URI = "git://github.com/ros2-gbp/rqt_multiplot_plugin-release;${ROS_BRANCH};protocol=https"
SRCREV = "7793bd2a5be564b221cc4ace9de9e6de3c9839c2"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

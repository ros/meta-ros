# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Reusable ROS 2 LiDAR-camera fusion. Matches 2D object detections     (vision_msgs/Detection2DArray) to LaserScan points, producing range-resolved,     semantically labeled obstacles and class-aware footprint polygons for navigation."
AUTHOR = "Aarav Bansal <aaravbansal.x@gmail.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=7d16fc53009020edbcd0b47b3441667c"

ROS_CN = "scan_detection_fusion"
ROS_BPN = "scan_detection_fusion"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = ""

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    builtin-interfaces \
    geometry-msgs \
    python3-numpy \
    rclpy \
    sensor-msgs \
    std-msgs \
    tf2-ros \
    vision-msgs \
    visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    python3-pytest \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/HexboxRC/scan_detection_fusion-release/archive/release/jazzy/scan_detection_fusion/0.1.0-2.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/scan_detection_fusion"
SRC_URI = "git://github.com/HexboxRC/scan_detection_fusion-release;${ROS_BRANCH};protocol=https"
SRCREV = "e06de1c5a45c8d413198d4dea05417c58fc861a1"

ROS_BUILD_TYPE = "ament_python"

inherit ros_${ROS_BUILD_TYPE}

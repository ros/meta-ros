# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "ros2_control hardware interface for JointCommand topic based control"
AUTHOR = "Marq Rasmussen <marq.razz@gmail.com>"
ROS_AUTHOR = "Kamalkant Thangaraju <itzkamalkant@gmail.com>"
HOMEPAGE = "https://github.com/ros-controls/topic_based_hardware_interfaces"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "topic_based_hardware_interfaces"
ROS_BPN = "joint_command_topic_hardware_interface"

ROS_BUILD_DEPENDS = "\
    angles \
    control-msgs \
    hardware-interface \
    rclcpp \
    realtime-tools \
    ros2-control-cmake \
    sensor-msgs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    angles \
    control-msgs \
    hardware-interface \
    rclcpp \
    realtime-tools \
    sensor-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    angles \
    control-msgs \
    hardware-interface \
    rclcpp \
    realtime-tools \
    sensor-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gmock \
    ros2-control-test-assets \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/topic_based_hardware-release/archive/release/jazzy/joint_command_topic_hardware_interface/1.2.0-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/joint_command_topic_hardware_interface"
SRC_URI = "git://github.com/ros2-gbp/topic_based_hardware-release;${ROS_BRANCH};protocol=https"
SRCREV = "49f0bd53341d2b01bb182a8af1462b81eedfed1f"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

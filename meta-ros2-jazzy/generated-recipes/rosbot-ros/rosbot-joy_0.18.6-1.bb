# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "The rosbot_joy package to handle joystick inputs for the rosbot and open manipulator"
AUTHOR = "Husarion <support@husarion.com>"
ROS_AUTHOR = "Rafal Gorecki <rafal.gorecki@husarion.com>"
HOMEPAGE = "https://husarion.com/"
SECTION = "devel"
# Original license in package.xml, joined with "&" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "rosbot_ros"
ROS_BPN = "rosbot_joy"

ROS_BUILD_DEPENDS = " \
    builtin-interfaces \
    control-msgs \
    geometry-msgs \
    moveit-msgs \
    moveit-ros-planning \
    moveit-ros-planning-interface \
    moveit-servo \
    rclcpp \
    sensor-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    builtin-interfaces \
    control-msgs \
    geometry-msgs \
    moveit-msgs \
    moveit-ros-planning \
    moveit-ros-planning-interface \
    moveit-servo \
    rclcpp \
    sensor-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    builtin-interfaces \
    control-msgs \
    geometry-msgs \
    joy \
    launch \
    launch-ros \
    moveit-msgs \
    moveit-ros-planning \
    moveit-ros-planning-interface \
    moveit-servo \
    rclcpp \
    sensor-msgs \
    teleop-twist-joy \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/rosbot_ros-release/archive/release/jazzy/rosbot_joy/0.18.6-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/rosbot_joy"
SRC_URI = "git://github.com/ros2-gbp/rosbot_ros-release;${ROS_BRANCH};protocol=https"
SRCREV = "138227dfe3dd8edd23f490b5cd870076d94ac706"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

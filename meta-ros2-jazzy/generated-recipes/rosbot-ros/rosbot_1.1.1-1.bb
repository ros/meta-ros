# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Meta package that contains all packages of ROSbot Series"
AUTHOR = "Husarion <support@husarion.com>"
ROS_AUTHOR = "Jakub Delicat <jakub.delicat@husarion.com>"
HOMEPAGE = "https://husarion.com"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "rosbot_ros"
ROS_BPN = "rosbot"

ROS_BUILD_DEPENDS = "\
    rosbot-controller \
    rosbot-description \
    rosbot-hardware-interfaces \
    rosbot-joy \
    rosbot-localization \
    rosbot-moveit \
    rosbot-utils \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
"

ROS_EXPORT_DEPENDS = "\
    rosbot-controller \
    rosbot-description \
    rosbot-hardware-interfaces \
    rosbot-joy \
    rosbot-localization \
    rosbot-moveit \
    rosbot-utils \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    rosbot-controller \
    rosbot-description \
    rosbot-hardware-interfaces \
    rosbot-joy \
    rosbot-localization \
    rosbot-moveit \
    rosbot-utils \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/rosbot_ros-release/archive/release/jazzy/rosbot/1.1.1-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/rosbot"
SRC_URI = "git://github.com/ros2-gbp/rosbot_ros-release;${ROS_BRANCH};protocol=https"
SRCREV = "d0c83be280cde2af798dbd98c3f88fdf4a5bcd10"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

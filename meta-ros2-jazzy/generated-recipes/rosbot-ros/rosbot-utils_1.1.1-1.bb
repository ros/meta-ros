# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Utilities for ROSbot Series"
AUTHOR = "Husarion <support@husarion.com>"
ROS_AUTHOR = "Dominik Nowak <dominik.nwk@gmail.com>"
HOMEPAGE = "https://husarion.com/"
SECTION = "devel"
# Original license in package.xml, joined with "AND" when multiple license tags were used:
#         "Apache License 2.0"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_CN = "rosbot_ros"
ROS_BPN = "rosbot_utils"

ROS_BUILD_DEPENDS = "\
    generate-parameter-library \
    rclcpp \
    sensor-msgs \
    std-srvs \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    ament-cmake-python-native \
"

ROS_EXPORT_DEPENDS = "\
    generate-parameter-library \
    rclcpp \
    sensor-msgs \
    std-srvs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    ${ROS_UNRESOLVED_DEP-python3-ftdi} \
    ${ROS_UNRESOLVED_DEP-python3-libgpiod} \
    ${ROS_UNRESOLVED_DEP-python3-sh} \
    ${ROS_UNRESOLVED_DEP-stm32flash} \
    alsa-utils \
    generate-parameter-library \
    launch-ros \
    python3-argcomplete \
    python3-pyserial \
    python3-pyudev \
    rclcpp \
    sensor-msgs \
    std-srvs \
    usbutils \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-pytest \
    launch \
    launch-pytest \
    launch-ros \
    launch-testing \
    python3-pytest \
    python3-pyyaml \
    rclpy \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/rosbot_ros-release/archive/release/jazzy/rosbot_utils/1.1.1-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/rosbot_utils"
SRC_URI = "git://github.com/ros2-gbp/rosbot_ros-release;${ROS_BRANCH};protocol=https"
SRCREV = "14fbced78f6e7c0b65bf646043594b69c121ff2a"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

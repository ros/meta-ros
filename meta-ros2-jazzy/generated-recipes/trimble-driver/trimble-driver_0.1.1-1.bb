# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Connect Trimble products publishing GSOF data to ROS."
AUTHOR = "Andre Nguyen <andre_nguyen@trimble.com>"
ROS_AUTHOR = "Andre Nguyen <andre_nguyen@trimble.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=13;endline=13;md5=2ac6d860cb803e383c653bdc1d2758c1"

ROS_CN = "trimble_driver"
ROS_BPN = "trimble_driver"

ROS_BUILD_DEPENDS = "\
    boost \
    diagnostic-msgs \
    geographiclib \
    geometry-msgs \
    libpcap \
    nav-msgs \
    rclcpp \
    rclcpp-components \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
    trimble-gsof-msgs \
    trimble-interfaces \
"

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-ros-native \
"

ROS_EXPORT_DEPENDS = "\
    boost \
    diagnostic-msgs \
    geographiclib \
    geometry-msgs \
    libpcap \
    nav-msgs \
    rclcpp \
    rclcpp-components \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
    trimble-gsof-msgs \
    trimble-interfaces \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    boost \
    diagnostic-msgs \
    geographiclib \
    geometry-msgs \
    libpcap \
    nav-msgs \
    rclcpp \
    rclcpp-components \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf2 \
    tf2-geometry-msgs \
    tf2-ros \
    trimble-gsof-msgs \
    trimble-interfaces \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-cmake-gtest \
    launch-testing \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/trimble_driver_ros-release/archive/release/jazzy/trimble_driver/0.1.1-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/trimble_driver"
SRC_URI = "git://github.com/ros2-gbp/trimble_driver_ros-release;${ROS_BRANCH};protocol=https"
SRCREV = "f383b2d359216d598436c734a46805efa721ff1c"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

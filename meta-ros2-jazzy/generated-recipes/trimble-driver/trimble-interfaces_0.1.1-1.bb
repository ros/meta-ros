# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Trimble interfaces"
AUTHOR = "Andre Nguyen <andre_nguyen@trimble.com>"
ROS_AUTHOR = "Andre Nguyen <andre_nguyen@trimble.com>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=2ac6d860cb803e383c653bdc1d2758c1"

ROS_CN = "trimble_driver"
ROS_BPN = "trimble_interfaces"

ROS_BUILD_DEPENDS = ""

ROS_BUILDTOOL_DEPENDS = "\
    ament-cmake-native \
    rosidl-default-generators-native \
"

ROS_EXPORT_DEPENDS = ""

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = "\
    rosidl-default-runtime \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "\
    ament-lint-common \
"

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros2-gbp/trimble_driver_ros-release/archive/release/jazzy/trimble_interfaces/0.1.1-1.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/trimble_interfaces"
SRC_URI = "git://github.com/ros2-gbp/trimble_driver_ros-release;${ROS_BRANCH};protocol=https"
SRCREV = "fb58c864a726bfec533cd9b9141fda75a0928439"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

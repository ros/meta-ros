# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_jazzy
inherit ros_superflore_generated

DESCRIPTION = "Depthai ROS Monolithic node."
AUTHOR = "Matevz Morato <matevz.morato@luxonis.com>"
ROS_AUTHOR = "Adam Serafin"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=58e54c03ca7f821dd3967e2a2cd1596e"

ROS_CN = "depthai_ros_v3"
ROS_BPN = "depthai_ros_driver_v3"

ROS_BUILD_DEPENDS = " \
    ament-cmake-auto \
    backward-ros \
    camera-calibration \
    camera-info-manager \
    cv-bridge \
    depthai-bridge-v3 \
    depthai-descriptions-v3 \
    depthai-ros-msgs-v3 \
    depthai-v3 \
    diagnostic-msgs \
    diagnostic-updater \
    ffmpeg-image-transport-msgs \
    geometry-msgs \
    image-pipeline \
    image-transport \
    image-transport-plugins \
    nav-msgs \
    pluginlib \
    rclcpp \
    rclcpp-components \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf2-ros \
    vision-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ament-cmake-native \
    ament-cmake-python-native \
"

ROS_EXPORT_DEPENDS = " \
    ament-cmake-auto \
    backward-ros \
    camera-calibration \
    camera-info-manager \
    cv-bridge \
    depthai-bridge-v3 \
    depthai-descriptions-v3 \
    depthai-ros-msgs-v3 \
    depthai-v3 \
    diagnostic-msgs \
    diagnostic-updater \
    ffmpeg-image-transport-msgs \
    geometry-msgs \
    image-pipeline \
    image-transport \
    image-transport-plugins \
    nav-msgs \
    pluginlib \
    rclcpp \
    rclcpp-components \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf2-ros \
    vision-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ament-cmake-auto \
    backward-ros \
    camera-calibration \
    camera-info-manager \
    cv-bridge \
    depthai-bridge-v3 \
    depthai-descriptions-v3 \
    depthai-ros-msgs-v3 \
    depthai-v3 \
    diagnostic-msgs \
    diagnostic-updater \
    ffmpeg-image-transport-msgs \
    geometry-msgs \
    image-pipeline \
    image-transport \
    image-transport-plugins \
    nav-msgs \
    pluginlib \
    rclcpp \
    rclcpp-components \
    sensor-msgs \
    std-msgs \
    std-srvs \
    tf2-ros \
    vision-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS:${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/luxonis/depthai-ros-v3-release/archive/release/jazzy/depthai_ros_driver_v3/3.1.1-2.tar.gz
ROS_BRANCH ?= "branch=release/jazzy/depthai_ros_driver_v3"
SRC_URI = "git://github.com/luxonis/depthai-ros-v3-release;${ROS_BRANCH};protocol=https"
SRCREV = "75873716873b08d8e1f089dd4e67bac5ef00916f"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}

DESCRIPTION = "The formatters here simply format various input types to a specified text format."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-license ecl-config ecl-exceptions ecl-converters"

require ecl-core.inc

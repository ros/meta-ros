DESCRIPTION = "This package provides the c++ extensions for a variety of threaded programming tools."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-license ecl-build ecl-config ecl-errors ecl-concepts ecl-exceptions ecl-time ecl-utilities"

require ecl-core.inc

DESCRIPTION = "Internal packaging of the 0.91 version of the simple python EBNF parser written by LParis."
SECTION = "devel"
LICENSE = "GPL"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=162b49cfbae9eadf37c9b89b2d2ac6be"

DEPENDS = "${PYTHON_PN}-catkin-pkg"

require rocon-tools.inc

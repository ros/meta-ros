DESCRIPTION = "Yujin open control system rapps for use with the app manager and rocon concert"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d566ef916e9dedc494f5f793a6690ba5"

require yujin-ocs.inc

DESCRIPTION = "Virtual sensor that uses semantic map information to see obstacles undetectable by robot sensors."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "tf roscpp sensor-msgs geometry-msgs yocs-msgs yocs-math-toolkit"

require yujin-ocs.inc

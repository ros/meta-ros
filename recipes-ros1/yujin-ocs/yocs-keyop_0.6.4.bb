DESCRIPTION = "Keyboard teleoperation for your robot"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "roscpp geometry-msgs std-msgs ecl-exceptions ecl-threads ecl-time"

require yujin-ocs.inc

DESCRIPTION = "ROS Python and C++ interfaces for universally unique identifiers."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "roscpp rospy uuid-msgs"

require unique-identifier.inc

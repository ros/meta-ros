DESCRIPTION = "camera_calibration allows easy calibration of monocular or stereo cameras using a \
checkerboard calibration target."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=23;endline=23;md5=d566ef916e9dedc494f5f793a6690ba5"

require image-pipeline.inc

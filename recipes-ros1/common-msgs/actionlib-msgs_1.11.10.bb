DESCRIPTION = "actionlib_msgs defines the common messages to interact with an \
action server and an action client."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d566ef916e9dedc494f5f793a6690ba5"

require common-msgs.inc

DESCRIPTION = "Provides a portable set of time functions that are especially \
  useful for porting other code or being wrapped by higher level c++ classes."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-build ecl-license ecl-config ecl-errors"

require ecl-lite.inc

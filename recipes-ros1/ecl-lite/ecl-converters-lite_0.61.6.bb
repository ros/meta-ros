DESCRIPTION = "These are a very simple version of some of the functions in ecl_converters suitable for firmware development."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "ecl-license ecl-config"

require ecl-lite.inc
